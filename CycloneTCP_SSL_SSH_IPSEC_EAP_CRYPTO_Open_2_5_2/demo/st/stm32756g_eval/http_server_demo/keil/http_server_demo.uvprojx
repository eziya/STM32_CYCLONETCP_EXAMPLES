# Keil uVision project http_server_demo.uvprojx, settings and files
target http_server_demo_flash (ARM-ADS)
  device: STM32F756NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: http_server_demo_flash
  BeforeMake: ..\..\..\..\..\utils\ResourceCompiler\bin\rc.exe ..\resources\ ..\src\res.c
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F756xx USE_HAL_DRIVER USE_STM32756G_EVAL USE_IOEXPANDER
  c include: ..\src;..\..\..\..\..\third_party\cmsis\core\include;..\..\..\..\..\third_party\st\devices\stm32f7xx;..\..\..\..\..\third_party\st\drivers\stm32f7xx_hal_driver\inc;..\..\..\..\..\third_party\st\boards\stm32756g_eval;..\..\..\..\..\third_party\freertos\include;..\..\..\..\..\third_party\freertos\portable\rvds\arm_cm7\r0p1;..\..\..\..\..\common;..\..\..\..\..\cyclone_tcp;..\..\..\..\..\cyclone_crypto
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: .\stm32f756_flash.sct
  group Demo Sources
    ./: startup_stm32f756xx.s retarget.c
    ../src/: system_stm32f7xx.c stm32f7xx_it.c main.c smi_driver.c debug.c res.c
  group Demo Headers
    ../src/: os_port_config.h net_config.h crypto_config.h FreeRTOSConfig.h stm32f7xx_hal_conf.h stm32f7xx_it.h smi_driver.h
  group Common Sources
    ../../../../../common/: cpu_endian.c os_port_freertos.c date_time.c str.c path.c resource_manager.c
  group Common Headers
    ../../../../../common/: cpu_endian.h os_port.h os_port_freertos.h date_time.h str.h path.h resource_manager.h error.h debug.h
  group CycloneTCP Sources
    ../../../../../cyclone_tcp/core/: net.c net_mem.c net_misc.c nic.c ethernet.c ethernet_misc.c ip.c tcp.c tcp_fsm.c tcp_misc.c tcp_timer.c udp.c socket.c socket_misc.c bsd_socket.c bsd_socket_options.c bsd_socket_misc.c raw_socket.c
    ../../../../../cyclone_tcp/drivers/mac/: stm32f7xx_eth_driver.c
    ../../../../../cyclone_tcp/drivers/phy/: dp83848_driver.c
    ../../../../../cyclone_tcp/ipv4/: arp.c arp_cache.c ipv4.c ipv4_frag.c ipv4_multicast.c ipv4_misc.c icmp.c
    ../../../../../cyclone_tcp/igmp/: igmp_host.c igmp_host_misc.c igmp_common.c igmp_debug.c
    ../../../../../cyclone_tcp/ipv6/: ipv6.c ipv6_frag.c ipv6_multicast.c ipv6_pmtu.c ipv6_misc.c icmpv6.c ndp.c ndp_cache.c ndp_misc.c slaac.c slaac_misc.c
    ../../../../../cyclone_tcp/mld/: mld_node.c mld_node_misc.c mld_common.c mld_debug.c
    ../../../../../cyclone_tcp/dns/: dns_cache.c dns_client.c dns_common.c dns_debug.c
    ../../../../../cyclone_tcp/mdns/: mdns_client.c mdns_responder.c mdns_responder_misc.c mdns_common.c
    ../../../../../cyclone_tcp/netbios/: nbns_client.c nbns_responder.c nbns_common.c
    ../../../../../cyclone_tcp/llmnr/: llmnr_client.c llmnr_responder.c llmnr_common.c
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.c dhcp_client_fsm.c dhcp_client_misc.c dhcp_common.c dhcp_debug.c
    ../../../../../cyclone_tcp/http/: http_server.c http_server_auth.c http_server_misc.c mime.c ssi.c
  group CycloneTCP Headers
    ../../../../../cyclone_tcp/core/: net.h net_mem.h net_misc.h nic.h ethernet.h ethernet_misc.h ip.h tcp.h tcp_fsm.h tcp_misc.h tcp_timer.h udp.h socket.h socket_misc.h bsd_socket.h bsd_socket_options.h bsd_socket_misc.h raw_socket.h
    ../../../../../cyclone_tcp/drivers/mac/: stm32f7xx_eth_driver.h
    ../../../../../cyclone_tcp/drivers/phy/: dp83848_driver.h
    ../../../../../cyclone_tcp/ipv4/: arp.h arp_cache.h ipv4.h ipv4_frag.h ipv4_multicast.h ipv4_misc.h icmp.h
    ../../../../../cyclone_tcp/igmp/: igmp_host.h igmp_host_misc.h igmp_common.h igmp_debug.h
    ../../../../../cyclone_tcp/ipv6/: ipv6.h ipv6_frag.h ipv6_multicast.h ipv6_pmtu.h ipv6_misc.h icmpv6.h ndp.h ndp_cache.h ndp_misc.h slaac.h slaac_misc.h
    ../../../../../cyclone_tcp/mld/: mld_node.h mld_node_misc.h mld_common.h mld_debug.h
    ../../../../../cyclone_tcp/dns/: dns_cache.h dns_client.h dns_common.h dns_debug.h
    ../../../../../cyclone_tcp/mdns/: mdns_client.h mdns_responder.h mdns_responder_misc.h mdns_common.h
    ../../../../../cyclone_tcp/netbios/: nbns_client.h nbns_responder.h nbns_common.h
    ../../../../../cyclone_tcp/llmnr/: llmnr_client.h llmnr_responder.h llmnr_common.h
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.h dhcp_client_fsm.h dhcp_client_misc.h dhcp_common.h dhcp_debug.h
    ../../../../../cyclone_tcp/http/: http_server.h http_server_auth.h http_server_misc.h mime.h ssi.h
  group CycloneCRYPTO Sources
    ../../../../../cyclone_crypto/hardware/stm32f7xx/: stm32f7xx_crypto.c stm32f7xx_crypto_trng.c
    ../../../../../cyclone_crypto/hash/: md5.c
    ../../../../../cyclone_crypto/encoding/: base64.c
  group CycloneCRYPTO Headers
    ../../../../../cyclone_crypto/core/: crypto.h
    ../../../../../cyclone_crypto/hardware/stm32f7xx/: stm32f7xx_crypto.h stm32f7xx_crypto_trng.h
    ../../../../../cyclone_crypto/hash/: md5.h
    ../../../../../cyclone_crypto/encoding/: base64.h
  group FreeRTOS Sources
    ../../../../../third_party/freertos/portable/rvds/arm_cm7/r0p1/: port.c
    ../../../../../third_party/freertos/: croutine.c list.c queue.c tasks.c timers.c
    ../../../../../third_party/freertos/portable/memmang/: heap_3.c
  group FreeRTOS Headers
    ../../../../../third_party/freertos/portable/rvds/arm_cm7/r0p1/: portmacro.h
    ../../../../../third_party/freertos/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h task.h timers.h
  group STM32756G-EVAL Sources
    ../../../../../third_party/st/boards/stm32756g_eval/: stm32756g_eval.c stm32756g_eval_camera.c stm32756g_eval_eeprom.c stm32756g_eval_io.c stm32756g_eval_lcd.c stm32756g_eval_nor.c stm32756g_eval_qspi.c stm32756g_eval_sd.c stm32756g_eval_sdram.c stm32756g_eval_sram.c stm32756g_eval_ts.c
    ../../../../../third_party/st/boards/components/exc7200/: exc7200.c
    ../../../../../third_party/st/boards/components/mfxstm32l152/: mfxstm32l152.c
    ../../../../../third_party/st/boards/components/ov5640/: ov5640.c
    ../../../../../third_party/st/boards/components/s5k5cag/: s5k5cag.c
    ../../../../../third_party/st/boards/components/stmpe811/: stmpe811.c
    ../../../../../third_party/st/boards/components/ts3510/: ts3510.c
  group STM32756G-EVAL Headers
    ../../../../../third_party/st/boards/stm32756g_eval/: stm32756g_eval.h stm32756g_eval_camera.h stm32756g_eval_eeprom.h stm32756g_eval_io.h stm32756g_eval_lcd.h stm32756g_eval_nor.h stm32756g_eval_qspi.h stm32756g_eval_sd.h stm32756g_eval_sdram.h stm32756g_eval_sram.h stm32756g_eval_ts.h
    ../../../../../third_party/st/boards/components/mfxstm32l152/: mfxstm32l152.h
    ../../../../../third_party/st/boards/components/exc7200/: exc7200.h
    ../../../../../third_party/st/boards/components/n25q512a/: n25q512a.h
    ../../../../../third_party/st/boards/components/ov5640/: ov5640.h
    ../../../../../third_party/st/boards/components/s5k5cag/: s5k5cag.h
    ../../../../../third_party/st/boards/components/stmpe811/: stmpe811.h
    ../../../../../third_party/st/boards/components/ts3510/: ts3510.h
  group STM32F7xx HAL Drivers Sources
    ../../../../../third_party/st/drivers/stm32f7xx_hal_driver/src/: stm32f7xx_hal.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_can.c stm32f7xx_hal_cec.c stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_cryp.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_dac.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_dcmi_ex.c stm32f7xx_hal_dfsdm.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_dsi.c stm32f7xx_hal_eth.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_hash.c stm32f7xx_hal_hash_ex.c stm32f7xx_hal_hcd.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_i2s.c stm32f7xx_hal_irda.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_jpeg.c stm32f7xx_hal_lptim.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_mdios.c stm32f7xx_hal_nand.c stm32f7xx_hal_nor.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_sdram.c stm32f7xx_hal_smartcard.c stm32f7xx_hal_smartcard_ex.c stm32f7xx_hal_spdifrx.c stm32f7xx_hal_spi.c stm32f7xx_hal_sram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_hal_wwdg.c stm32f7xx_ll_fmc.c stm32f7xx_ll_sdmmc.c stm32f7xx_ll_usb.c
  group STM32F7xx HAL Drivers Headers
    ../../../../../third_party/st/drivers/stm32f7xx_hal_driver/inc/: stm32f7xx_hal.h stm32f7xx_hal_adc.h stm32f7xx_hal_adc_ex.h stm32f7xx_hal_can.h stm32f7xx_hal_cec.h stm32f7xx_hal_cortex.h stm32f7xx_hal_crc.h stm32f7xx_hal_crc_ex.h stm32f7xx_hal_cryp.h stm32f7xx_hal_cryp_ex.h stm32f7xx_hal_dac.h stm32f7xx_hal_dac_ex.h stm32f7xx_hal_dcmi.h stm32f7xx_hal_dcmi_ex.h stm32f7xx_hal_def.h stm32f7xx_hal_dfsdm.h stm32f7xx_hal_dma.h stm32f7xx_hal_dma_ex.h stm32f7xx_hal_dma2d.h stm32f7xx_hal_dsi.h stm32f7xx_hal_eth.h stm32f7xx_hal_flash.h stm32f7xx_hal_flash_ex.h stm32f7xx_hal_gpio.h stm32f7xx_hal_gpio_ex.h stm32f7xx_hal_hash.h stm32f7xx_hal_hash_ex.h stm32f7xx_hal_hcd.h stm32f7xx_hal_i2c.h stm32f7xx_hal_i2c_ex.h stm32f7xx_hal_i2s.h stm32f7xx_hal_irda.h stm32f7xx_hal_irda_ex.h stm32f7xx_hal_iwdg.h stm32f7xx_hal_jpeg.h stm32f7xx_hal_lptim.h stm32f7xx_hal_ltdc.h stm32f7xx_hal_ltdc_ex.h stm32f7xx_hal_mdios.h stm32f7xx_hal_nand.h stm32f7xx_hal_nor.h stm32f7xx_hal_pcd.h stm32f7xx_hal_pcd_ex.h stm32f7xx_hal_pwr.h stm32f7xx_hal_pwr_ex.h stm32f7xx_hal_qspi.h stm32f7xx_hal_rcc.h stm32f7xx_hal_rcc_ex.h stm32f7xx_hal_rng.h stm32f7xx_hal_rtc.h stm32f7xx_hal_rtc_ex.h stm32f7xx_hal_sai.h stm32f7xx_hal_sai_ex.h stm32f7xx_hal_sd.h stm32f7xx_hal_sdram.h stm32f7xx_hal_smartcard.h stm32f7xx_hal_smartcard_ex.h stm32f7xx_hal_spdifrx.h stm32f7xx_hal_spi.h stm32f7xx_hal_sram.h stm32f7xx_hal_tim.h stm32f7xx_hal_tim_ex.h stm32f7xx_hal_uart.h stm32f7xx_hal_uart_ex.h stm32f7xx_hal_usart.h stm32f7xx_hal_usart_ex.h stm32f7xx_hal_wwdg.h stm32f7xx_ll_fmc.h stm32f7xx_ll_sdmmc.h stm32f7xx_ll_usb.h
target http_server_demo_sram (ARM-ADS)
  device: STM32F756NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: as above
  output: http_server_demo_sram
  BeforeMake: as above
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F756xx USE_HAL_DRIVER USE_STM32756G_EVAL USE_IOEXPANDER
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: .\stm32f756_sram.sct
