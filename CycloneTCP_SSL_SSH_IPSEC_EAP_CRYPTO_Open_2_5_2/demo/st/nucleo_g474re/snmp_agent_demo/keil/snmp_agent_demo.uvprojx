# Keil uVision project snmp_agent_demo.uvprojx, settings and files
target snmp_agent_demo_flash (ARM-ADS)
  device: STM32G474RETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.4.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: snmp_agent_demo_flash
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32G474xx USE_HAL_DRIVER USE_NUCLEO_64 USE_W5500
  c include: ..\src;..\..\..\..\..\third_party\cmsis\core\include;..\..\..\..\..\third_party\st\devices\stm32g4xx;..\..\..\..\..\third_party\st\drivers\stm32g4xx_hal_driver\inc;..\..\..\..\..\third_party\st\boards\stm32g4xx_nucleo;..\..\..\..\..\common;..\..\..\..\..\cyclone_tcp;..\..\..\..\..\cyclone_crypto
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\stm32g474_flash.sct
  group Demo Sources
    ./: startup_stm32g474xx.s retarget.c
    ../src/: system_stm32g4xx.c stm32g4xx_it.c main.c private_mib_module.c private_mib_impl.c debug.c spi_driver.c ext_int_driver.c
  group Demo Headers
    ../src/: os_port_config.h net_config.h crypto_config.h stm32g4xx_hal_conf.h stm32g4xx_it.h stm32g4xx_nucleo_conf.h private_mib_module.h private_mib_impl.h spi_driver.h ext_int_driver.h
  group Common Sources
    ../../../../../common/: cpu_endian.c os_port_none.c date_time.c str.c
  group Common Headers
    ../../../../../common/: cpu_endian.h os_port.h os_port_none.h date_time.h str.h error.h debug.h
  group CycloneTCP Sources
    ../../../../../cyclone_tcp/core/: net.c net_mem.c net_misc.c nic.c ethernet.c ethernet_misc.c ip.c tcp.c tcp_fsm.c tcp_misc.c tcp_timer.c udp.c socket.c socket_misc.c bsd_socket.c bsd_socket_options.c bsd_socket_misc.c raw_socket.c
    ../../../../../cyclone_tcp/drivers/eth/: w3150a_driver.c w5100_driver.c w5100s_driver.c w5200_driver.c w5500_driver.c w6100_driver.c
    ../../../../../cyclone_tcp/ipv4/: arp.c arp_cache.c ipv4.c ipv4_frag.c ipv4_multicast.c ipv4_misc.c icmp.c
    ../../../../../cyclone_tcp/igmp/: igmp_host.c igmp_host_misc.c igmp_common.c igmp_debug.c
    ../../../../../cyclone_tcp/ipv6/: ipv6.c ipv6_frag.c ipv6_multicast.c ipv6_pmtu.c ipv6_misc.c icmpv6.c ndp.c ndp_cache.c ndp_misc.c slaac.c slaac_misc.c
    ../../../../../cyclone_tcp/mld/: mld_node.c mld_node_misc.c mld_common.c mld_debug.c
    ../../../../../cyclone_tcp/dns/: dns_cache.c dns_client.c dns_common.c dns_debug.c
    ../../../../../cyclone_tcp/mdns/: mdns_client.c mdns_responder.c mdns_responder_misc.c mdns_common.c
    ../../../../../cyclone_tcp/netbios/: nbns_client.c nbns_responder.c nbns_common.c
    ../../../../../cyclone_tcp/llmnr/: llmnr_client.c llmnr_responder.c llmnr_common.c
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.c dhcp_client_fsm.c dhcp_client_misc.c dhcp_common.c dhcp_debug.c
    ../../../../../cyclone_tcp/snmp/: snmp_agent.c snmp_agent_dispatch.c snmp_agent_message.c snmp_agent_pdu.c snmp_agent_object.c snmp_agent_trap.c snmp_agent_inform.c snmp_agent_usm.c snmp_agent_vacm.c snmp_agent_misc.c
    ../../../../../cyclone_tcp/mibs/: mib_common.c mib2_module.c mib2_impl.c mib2_impl_sys.c mib2_impl_if.c mib2_impl_ip.c mib2_impl_tcp.c mib2_impl_udp.c
  group CycloneTCP Headers
    ../../../../../cyclone_tcp/core/: net.h net_mem.h net_misc.h nic.h ethernet.h ethernet_misc.h ip.h tcp.h tcp_fsm.h tcp_misc.h tcp_timer.h udp.h socket.h socket_misc.h bsd_socket.h bsd_socket_options.h bsd_socket_misc.h raw_socket.h
    ../../../../../cyclone_tcp/drivers/eth/: w3150a_driver.h w5100_driver.h w5100s_driver.h w5200_driver.h w5500_driver.h w6100_driver.h
    ../../../../../cyclone_tcp/ipv4/: arp.h arp_cache.h ipv4.h ipv4_frag.h ipv4_multicast.h ipv4_misc.h icmp.h
    ../../../../../cyclone_tcp/igmp/: igmp_host.h igmp_host_misc.h igmp_common.h igmp_debug.h
    ../../../../../cyclone_tcp/ipv6/: ipv6.h ipv6_frag.h ipv6_multicast.h ipv6_pmtu.h ipv6_misc.h icmpv6.h ndp.h ndp_cache.h ndp_misc.h slaac.h slaac_misc.h
    ../../../../../cyclone_tcp/mld/: mld_node.h mld_node_misc.h mld_common.h mld_debug.h
    ../../../../../cyclone_tcp/dns/: dns_cache.h dns_client.h dns_common.h dns_debug.h
    ../../../../../cyclone_tcp/mdns/: mdns_client.h mdns_responder.h mdns_responder_misc.h mdns_common.h
    ../../../../../cyclone_tcp/netbios/: nbns_client.h nbns_responder.h nbns_common.h
    ../../../../../cyclone_tcp/llmnr/: llmnr_client.h llmnr_responder.h llmnr_common.h
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.h dhcp_client_fsm.h dhcp_client_misc.h dhcp_common.h dhcp_debug.h
    ../../../../../cyclone_tcp/snmp/: snmp_agent.h snmp_agent_dispatch.h snmp_agent_message.h snmp_agent_pdu.h snmp_agent_object.h snmp_agent_trap.h snmp_agent_inform.h snmp_agent_usm.h snmp_agent_vacm.h snmp_agent_misc.h snmp_common.h
    ../../../../../cyclone_tcp/mibs/: mib_common.h mib2_module.h mib2_impl.h mib2_impl_sys.h mib2_impl_if.h mib2_impl_ip.h mib2_impl_tcp.h mib2_impl_udp.h
  group CycloneCRYPTO Sources
    ../../../../../cyclone_crypto/hardware/stm32g4xx/: stm32g4xx_crypto.c stm32g4xx_crypto_trng.c
    ../../../../../cyclone_crypto/hash/: md5.c sha1.c
    ../../../../../cyclone_crypto/mac/: hmac.c
    ../../../../../cyclone_crypto/cipher/: des.c aes.c
    ../../../../../cyclone_crypto/cipher_modes/: cbc.c cfb.c
    ../../../../../cyclone_crypto/encoding/: asn1.c oid.c
  group CycloneCRYPTO Headers
    ../../../../../cyclone_crypto/core/: crypto.h
    ../../../../../cyclone_crypto/hardware/stm32g4xx/: stm32g4xx_crypto.h stm32g4xx_crypto_trng.h
    ../../../../../cyclone_crypto/hash/: md5.h sha1.h
    ../../../../../cyclone_crypto/mac/: hmac.h
    ../../../../../cyclone_crypto/cipher/: des.h aes.h
    ../../../../../cyclone_crypto/cipher_modes/: cbc.h cfb.h
    ../../../../../cyclone_crypto/encoding/: asn1.h oid.h
  group Nucleo-G474RE Sources
    ../../../../../third_party/st/boards/stm32g4xx_nucleo/: stm32g4xx_nucleo.c
  group Nucleo-G474RE Headers
    ../../../../../third_party/st/boards/stm32g4xx_nucleo/: stm32g4xx_nucleo.h
  group STM32G4xx HAL Drivers Sources
    ../../../../../third_party/st/drivers/stm32g4xx_hal_driver/src/: stm32g4xx_hal.c stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_crc.c stm32g4xx_hal_crc_ex.c stm32g4xx_hal_cryp.c stm32g4xx_hal_cryp_ex.c stm32g4xx_hal_dac.c stm32g4xx_hal_dac_ex.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_exti.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_i2c.c stm32g4xx_hal_i2c_ex.c stm32g4xx_hal_i2s.c stm32g4xx_hal_irda.c stm32g4xx_hal_iwdg.c stm32g4xx_hal_lptim.c stm32g4xx_hal_nand.c stm32g4xx_hal_nor.c stm32g4xx_hal_pcd.c stm32g4xx_hal_pcd_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_qspi.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_rng.c stm32g4xx_hal_rtc.c stm32g4xx_hal_rtc_ex.c stm32g4xx_hal_sai.c stm32g4xx_hal_sai_ex.c stm32g4xx_hal_smartcard.c stm32g4xx_hal_smartcard_ex.c stm32g4xx_hal_spi.c stm32g4xx_hal_sram.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c stm32g4xx_hal_usart.c stm32g4xx_hal_usart_ex.c stm32g4xx_hal_wwdg.c stm32g4xx_ll_fmc.c stm32g4xx_ll_usb.c
  group STM32G4xx HAL Drivers Headers
    ../../../../../third_party/st/drivers/stm32g4xx_hal_driver/inc/: stm32g4xx_hal.h stm32g4xx_hal_adc.h stm32g4xx_hal_adc_ex.h stm32g4xx_hal_cortex.h stm32g4xx_hal_crc.h stm32g4xx_hal_crc_ex.h stm32g4xx_hal_cryp.h stm32g4xx_hal_cryp_ex.h stm32g4xx_hal_dac.h stm32g4xx_hal_dac_ex.h stm32g4xx_hal_def.h stm32g4xx_hal_dma.h stm32g4xx_hal_dma_ex.h stm32g4xx_hal_flash.h stm32g4xx_hal_flash_ex.h stm32g4xx_hal_flash_ramfunc.h stm32g4xx_hal_gpio.h stm32g4xx_hal_gpio_ex.h stm32g4xx_hal_hcd.h stm32g4xx_hal_i2c.h stm32g4xx_hal_i2c_ex.h stm32g4xx_hal_i2s.h stm32g4xx_hal_irda.h stm32g4xx_hal_iwdg.h stm32g4xx_hal_lptim.h stm32g4xx_hal_nand.h stm32g4xx_hal_nor.h stm32g4xx_hal_pcd.h stm32g4xx_hal_pcd_ex.h stm32g4xx_hal_pwr.h stm32g4xx_hal_pwr_ex.h stm32g4xx_hal_qspi.h stm32g4xx_hal_rcc.h stm32g4xx_hal_rcc_ex.h stm32g4xx_hal_rng.h stm32g4xx_hal_rtc.h stm32g4xx_hal_rtc_ex.h stm32g4xx_hal_sai.h stm32g4xx_hal_sai_ex.h stm32g4xx_hal_smartcard.h stm32g4xx_hal_smartcard_ex.h stm32g4xx_hal_spi.h stm32g4xx_hal_sram.h stm32g4xx_hal_tim.h stm32g4xx_hal_tim_ex.h stm32g4xx_hal_uart.h stm32g4xx_hal_uart_ex.h stm32g4xx_hal_usart.h stm32g4xx_hal_usart_ex.h stm32g4xx_hal_wwdg.h stm32g4xx_ll_fmc.h stm32g4xx_ll_usb.h
    ../../../../../third_party/st/drivers/stm32g4xx_hal_driver/src/: stm32g4xx_hal_exti.h
target snmp_agent_demo_sram (ARM-ADS)
  device: STM32G474RETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.4.0
  cpu: as above
  output: snmp_agent_demo_sram
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32G474xx USE_HAL_DRIVER USE_NUCLEO_64 USE_W5500
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\stm32g474_sram.sct
