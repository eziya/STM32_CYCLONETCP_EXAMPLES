# Keil uVision project http_server_demo.uvprojx, settings and files
target http_server_demo_flash (ARM-ADS)
  device: STM32L562QEIxQ STMicroelectronics
  pack: Keil.STM32L5xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x30000000,0x00040000) IROM(0x08000000,0x00080000) IROM2(0x0C000000,0x00080000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: http_server_demo_flash
  BeforeMake: ..\..\..\..\..\utils\ResourceCompiler\bin\rc.exe ..\resources\ ..\src\res.c
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32L562xx USE_HAL_DRIVER USE_STM32L562E_DISCO __USE_C99_MATH
  c include: ..\src;..\..\..\..\..\third_party\cmsis\core\include;..\..\..\..\..\third_party\st\devices\stm32l5xx;..\..\..\..\..\third_party\st\drivers\stm32l5xx_hal_driver\inc;..\..\..\..\..\third_party\st\boards2\stm32l562e_discovery;..\..\..\..\..\third_party\st\boards2\components\common;..\..\..\..\..\third_party\st\boards2\utilities\lcd;..\..\..\..\..\third_party\freertos\include;..\..\..\..\..\third_party\freertos\portable\gcc\arm_cm33_ntz\non_secure;..\..\..\..\..\common;..\..\..\..\..\cyclone_tcp
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0xc000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x30000000 size 0x40000
  scatter file: .\stm32l562_flash.sct
  group Demo Sources
    ./: startup_stm32l562xx.s retarget.c
    ../src/: system_stm32l5xx.c stm32l5xx_it.c stm32l5xx_hal_timebase_tim.c main.c debug.c spi_driver.c ext_int_driver.c res.c
  group Demo Headers
    ../src/: os_port_config.h net_config.h FreeRTOSConfig.h stm32l5xx_hal_conf.h stm32l562e_discovery_conf.h stm32l5xx_it.h spi_driver.h ext_int_driver.h
  group Common Sources
    ../../../../../common/: cpu_endian.c os_port_freertos.c date_time.c str.c path.c resource_manager.c
  group Common Headers
    ../../../../../common/: cpu_endian.h os_port.h os_port_freertos.h date_time.h str.h path.h resource_manager.h error.h debug.h
  group CycloneTCP Sources
    ../../../../../cyclone_tcp/core/: net.c net_mem.c net_misc.c nic.c ethernet.c ethernet_misc.c ip.c tcp.c tcp_fsm.c tcp_misc.c tcp_timer.c udp.c socket.c socket_misc.c bsd_socket.c bsd_socket_options.c bsd_socket_misc.c raw_socket.c
    ../../../../../cyclone_tcp/drivers/eth/: enc624j600_driver.c
    ../../../../../cyclone_tcp/ipv4/: arp.c arp_cache.c ipv4.c ipv4_frag.c ipv4_multicast.c ipv4_misc.c icmp.c
    ../../../../../cyclone_tcp/igmp/: igmp_host.c igmp_host_misc.c igmp_common.c igmp_debug.c
    ../../../../../cyclone_tcp/ipv6/: ipv6.c ipv6_frag.c ipv6_multicast.c ipv6_pmtu.c ipv6_misc.c icmpv6.c ndp.c ndp_cache.c ndp_misc.c slaac.c slaac_misc.c
    ../../../../../cyclone_tcp/mld/: mld_node.c mld_node_misc.c mld_common.c mld_debug.c
    ../../../../../cyclone_tcp/dns/: dns_cache.c dns_client.c dns_common.c dns_debug.c
    ../../../../../cyclone_tcp/mdns/: mdns_client.c mdns_responder.c mdns_responder_misc.c mdns_common.c
    ../../../../../cyclone_tcp/netbios/: nbns_client.c nbns_responder.c nbns_common.c
    ../../../../../cyclone_tcp/llmnr/: llmnr_client.c llmnr_responder.c llmnr_common.c
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.c dhcp_client_fsm.c dhcp_client_misc.c dhcp_common.c dhcp_debug.c
    ../../../../../cyclone_tcp/http/: http_server.c http_server_auth.c http_server_misc.c mime.c ssi.c
  group CycloneTCP Headers
    ../../../../../cyclone_tcp/core/: net.h net_mem.h net_misc.h nic.h ethernet.h ethernet_misc.h ip.h tcp.h tcp_fsm.h tcp_misc.h tcp_timer.h udp.h socket.h socket_misc.h bsd_socket.h bsd_socket_options.h bsd_socket_misc.h raw_socket.h
    ../../../../../cyclone_tcp/drivers/eth/: enc624j600_driver.h
    ../../../../../cyclone_tcp/ipv4/: arp.h arp_cache.h ipv4.h ipv4_frag.h ipv4_multicast.h ipv4_misc.h icmp.h
    ../../../../../cyclone_tcp/igmp/: igmp_host.h igmp_host_misc.h igmp_common.h igmp_debug.h
    ../../../../../cyclone_tcp/ipv6/: ipv6.h ipv6_frag.h ipv6_multicast.h ipv6_pmtu.h ipv6_misc.h icmpv6.h ndp.h ndp_cache.h ndp_misc.h slaac.h slaac_misc.h
    ../../../../../cyclone_tcp/mld/: mld_node.h mld_node_misc.h mld_common.h mld_debug.h
    ../../../../../cyclone_tcp/dns/: dns_cache.h dns_client.h dns_common.h dns_debug.h
    ../../../../../cyclone_tcp/mdns/: mdns_client.h mdns_responder.h mdns_responder_misc.h mdns_common.h
    ../../../../../cyclone_tcp/netbios/: nbns_client.h nbns_responder.h nbns_common.h
    ../../../../../cyclone_tcp/llmnr/: llmnr_client.h llmnr_responder.h llmnr_common.h
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.h dhcp_client_fsm.h dhcp_client_misc.h dhcp_common.h dhcp_debug.h
    ../../../../../cyclone_tcp/http/: http_server.h http_server_auth.h http_server_misc.h mime.h ssi.h
  group FreeRTOS Sources
    ../../../../../third_party/freertos/portable/gcc/arm_cm33_ntz/non_secure/: port.c portasm.c
    ../../../../../third_party/freertos/: croutine.c list.c queue.c tasks.c timers.c
    ../../../../../third_party/freertos/portable/memmang/: heap_3.c
  group FreeRTOS Headers
    ../../../../../third_party/freertos/portable/gcc/arm_cm33_ntz/non_secure/: portmacro.h portasm.h
    ../../../../../third_party/freertos/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h task.h timers.h
  group STM32L562E-DK Sources
    ../../../../../third_party/st/boards2/stm32l562e_discovery/: stm32l562e_discovery.c stm32l562e_discovery_audio.c stm32l562e_discovery_bus.c stm32l562e_discovery_idd.c stm32l562e_discovery_lcd.c stm32l562e_discovery_motion_sensors.c stm32l562e_discovery_ospi.c stm32l562e_discovery_sd.c stm32l562e_discovery_ts.c
    ../../../../../third_party/st/boards2/components/cs42l51/: cs42l51.c cs42l51_reg.c
    ../../../../../third_party/st/boards2/components/ft6x06/: ft6x06.c ft6x06_reg.c
    ../../../../../third_party/st/boards2/components/lsm6dso/: lsm6dso.c lsm6dso_reg.c
    ../../../../../third_party/st/boards2/components/mx25lm51245g/: mx25lm51245g.c
    ../../../../../third_party/st/boards2/components/st7789h2/: st7789h2.c st7789h2_reg.c
    ../../../../../third_party/st/boards2/utilities/lcd/: stm32_lcd.c
  group STM32L562E-DK Headers
    ../../../../../third_party/st/boards2/stm32l562e_discovery/: stm32l562e_discovery.h stm32l562e_discovery_audio.h stm32l562e_discovery_bus.h stm32l562e_discovery_errno.h stm32l562e_discovery_idd.h stm32l562e_discovery_lcd.h stm32l562e_discovery_motion_sensors.h stm32l562e_discovery_ospi.h stm32l562e_discovery_sd.h stm32l562e_discovery_ts.h
    ../../../../../third_party/st/boards2/components/cs42l51/: cs42l51.h cs42l51_reg.h
    ../../../../../third_party/st/boards2/components/ft6x06/: ft6x06.h ft6x06_reg.h
    ../../../../../third_party/st/boards2/components/lsm6dso/: lsm6dso.h lsm6dso_reg.h
    ../../../../../third_party/st/boards2/components/mx25lm51245g/: mx25lm51245g.h
    ../../../../../third_party/st/boards2/components/st7789h2/: st7789h2.h st7789h2_reg.h
    ../../../../../third_party/st/boards2/utilities/lcd/: stm32_lcd.h
  group STM32L5xx HAL Drivers Sources
    ../../../../../third_party/st/drivers/stm32l5xx_hal_driver/src/: stm32l5xx_hal.c stm32l5xx_hal_adc.c stm32l5xx_hal_adc_ex.c stm32l5xx_hal_comp.c stm32l5xx_hal_cortex.c stm32l5xx_hal_crc.c stm32l5xx_hal_crc_ex.c stm32l5xx_hal_cryp.c stm32l5xx_hal_cryp_ex.c stm32l5xx_hal_dac.c stm32l5xx_hal_dac_ex.c stm32l5xx_hal_dfsdm.c stm32l5xx_hal_dfsdm_ex.c stm32l5xx_hal_dma.c stm32l5xx_hal_dma_ex.c stm32l5xx_hal_exti.c stm32l5xx_hal_fdcan.c stm32l5xx_hal_flash.c stm32l5xx_hal_flash_ex.c stm32l5xx_hal_flash_ramfunc.c stm32l5xx_hal_gpio.c stm32l5xx_hal_gtzc.c stm32l5xx_hal_hash.c stm32l5xx_hal_hash_ex.c stm32l5xx_hal_i2c.c stm32l5xx_hal_i2c_ex.c stm32l5xx_hal_icache.c stm32l5xx_hal_irda.c stm32l5xx_hal_iwdg.c stm32l5xx_hal_lptim.c stm32l5xx_hal_mmc.c stm32l5xx_hal_mmc_ex.c stm32l5xx_hal_nand.c stm32l5xx_hal_nor.c stm32l5xx_hal_opamp.c stm32l5xx_hal_opamp_ex.c stm32l5xx_hal_ospi.c stm32l5xx_hal_otfdec.c stm32l5xx_hal_pcd.c stm32l5xx_hal_pcd_ex.c stm32l5xx_hal_pka.c stm32l5xx_hal_pwr.c stm32l5xx_hal_pwr_ex.c stm32l5xx_hal_rcc.c stm32l5xx_hal_rcc_ex.c stm32l5xx_hal_rng.c stm32l5xx_hal_rng_ex.c stm32l5xx_hal_rtc.c stm32l5xx_hal_rtc_ex.c stm32l5xx_hal_sai.c stm32l5xx_hal_sai_ex.c stm32l5xx_hal_sd.c stm32l5xx_hal_sd_ex.c stm32l5xx_hal_smartcard.c stm32l5xx_hal_smartcard_ex.c stm32l5xx_hal_smbus.c stm32l5xx_hal_spi.c stm32l5xx_hal_spi_ex.c stm32l5xx_hal_sram.c stm32l5xx_hal_tim.c stm32l5xx_hal_tim_ex.c stm32l5xx_hal_tsc.c stm32l5xx_hal_uart.c stm32l5xx_hal_uart_ex.c stm32l5xx_hal_usart.c stm32l5xx_hal_usart_ex.c stm32l5xx_hal_wwdg.c stm32l5xx_ll_adc.c stm32l5xx_ll_comp.c stm32l5xx_ll_crc.c stm32l5xx_ll_crs.c stm32l5xx_ll_dac.c stm32l5xx_ll_dma.c stm32l5xx_ll_exti.c stm32l5xx_ll_fmc.c stm32l5xx_ll_gpio.c stm32l5xx_ll_i2c.c stm32l5xx_ll_lptim.c stm32l5xx_ll_lpuart.c stm32l5xx_ll_opamp.c stm32l5xx_ll_pka.c stm32l5xx_ll_pwr.c stm32l5xx_ll_rcc.c stm32l5xx_ll_rng.c stm32l5xx_ll_rtc.c stm32l5xx_ll_sdmmc.c stm32l5xx_ll_spi.c stm32l5xx_ll_tim.c stm32l5xx_ll_ucpd.c stm32l5xx_ll_usart.c stm32l5xx_ll_usb.c stm32l5xx_ll_utils.c
  group STM32L5xx HAL Drivers Headers
    ../../../../../third_party/st/drivers/stm32l5xx_hal_driver/inc/: stm32l5xx_hal.h stm32l5xx_hal_adc.h stm32l5xx_hal_adc_ex.h stm32l5xx_hal_comp.h stm32l5xx_hal_cortex.h stm32l5xx_hal_crc.h stm32l5xx_hal_crc_ex.h stm32l5xx_hal_cryp.h stm32l5xx_hal_cryp_ex.h stm32l5xx_hal_dac.h stm32l5xx_hal_dac_ex.h stm32l5xx_hal_def.h stm32l5xx_hal_dfsdm.h stm32l5xx_hal_dfsdm_ex.h stm32l5xx_hal_dma.h stm32l5xx_hal_dma_ex.h stm32l5xx_hal_exti.h stm32l5xx_hal_fdcan.h stm32l5xx_hal_flash.h stm32l5xx_hal_flash_ex.h stm32l5xx_hal_flash_ramfunc.h stm32l5xx_hal_gpio.h stm32l5xx_hal_gpio_ex.h stm32l5xx_hal_gtzc.h stm32l5xx_hal_hash.h stm32l5xx_hal_hash_ex.h stm32l5xx_hal_i2c.h stm32l5xx_hal_i2c_ex.h stm32l5xx_hal_icache.h stm32l5xx_hal_irda.h stm32l5xx_hal_irda_ex.h stm32l5xx_hal_iwdg.h stm32l5xx_hal_lptim.h stm32l5xx_hal_mmc.h stm32l5xx_hal_mmc_ex.h stm32l5xx_hal_nand.h stm32l5xx_hal_nor.h stm32l5xx_hal_opamp.h stm32l5xx_hal_opamp_ex.h stm32l5xx_hal_ospi.h stm32l5xx_hal_otfdec.h stm32l5xx_hal_pcd.h stm32l5xx_hal_pcd_ex.h stm32l5xx_hal_pka.h stm32l5xx_hal_pwr.h stm32l5xx_hal_pwr_ex.h stm32l5xx_hal_rcc.h stm32l5xx_hal_rcc_ex.h stm32l5xx_hal_rng.h stm32l5xx_hal_rng_ex.h stm32l5xx_hal_rtc.h stm32l5xx_hal_rtc_ex.h stm32l5xx_hal_sai.h stm32l5xx_hal_sai_ex.h stm32l5xx_hal_sd.h stm32l5xx_hal_sd_ex.h stm32l5xx_hal_smartcard.h stm32l5xx_hal_smartcard_ex.h stm32l5xx_hal_smbus.h stm32l5xx_hal_spi.h stm32l5xx_hal_spi_ex.h stm32l5xx_hal_sram.h stm32l5xx_hal_tim.h stm32l5xx_hal_tim_ex.h stm32l5xx_hal_tsc.h stm32l5xx_hal_uart.h stm32l5xx_hal_uart_ex.h stm32l5xx_hal_usart.h stm32l5xx_hal_usart_ex.h stm32l5xx_hal_wwdg.h stm32l5xx_ll_adc.h stm32l5xx_ll_bus.h stm32l5xx_ll_comp.h stm32l5xx_ll_cortex.h stm32l5xx_ll_crc.h stm32l5xx_ll_crs.h stm32l5xx_ll_dac.h stm32l5xx_ll_dma.h stm32l5xx_ll_dmamux.h stm32l5xx_ll_exti.h stm32l5xx_ll_fmc.h stm32l5xx_ll_gpio.h stm32l5xx_ll_i2c.h stm32l5xx_ll_iwdg.h stm32l5xx_ll_lptim.h stm32l5xx_ll_lpuart.h stm32l5xx_ll_opamp.h stm32l5xx_ll_pka.h stm32l5xx_ll_pwr.h stm32l5xx_ll_rcc.h stm32l5xx_ll_rng.h stm32l5xx_ll_rtc.h stm32l5xx_ll_sdmmc.h stm32l5xx_ll_spi.h stm32l5xx_ll_system.h stm32l5xx_ll_tim.h stm32l5xx_ll_ucpd.h stm32l5xx_ll_usart.h stm32l5xx_ll_usb.h stm32l5xx_ll_utils.h stm32l5xx_ll_wwdg.h
target http_server_demo_sram (ARM-ADS)
  device: STM32L562QEIxQ STMicroelectronics
  pack: Keil.STM32L5xx_DFP.1.1.0
  cpu: as above
  output: http_server_demo_sram
  BeforeMake: as above
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: as above
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0xc000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x30000000 size 0x40000
  scatter file: .\stm32l562_sram.sct
