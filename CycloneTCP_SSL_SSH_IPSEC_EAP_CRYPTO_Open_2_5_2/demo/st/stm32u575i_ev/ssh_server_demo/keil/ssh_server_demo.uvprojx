# Keil uVision project ssh_server_demo.uvprojx, settings and files
target ssh_server_demo_flash (ARM-ADS)
  device: STM32U575AIIxQ STMicroelectronics
  pack: Keil.STM32U5xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x20040000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: ssh_server_demo_flash
  BeforeMake: ..\..\..\..\..\utils\ResourceCompiler\bin\rc.exe ..\resources\ ..\src\res.c
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32U575xx USE_HAL_DRIVER USE_STM32U575I_EVAL __USE_C99_MATH
  c include: ..\src;..\..\..\..\..\third_party\cmsis\core\include;..\..\..\..\..\third_party\st\devices\stm32u5xx;..\..\..\..\..\third_party\st\drivers\stm32u5xx_hal_driver\inc;..\..\..\..\..\third_party\st\boards2\stm32u575i_eval;..\..\..\..\..\third_party\st\boards2\components\common;..\..\..\..\..\third_party\st\boards2\utilities\lcd;..\..\..\..\..\third_party\freertos\include;..\..\..\..\..\third_party\freertos\portable\gcc\arm_cm33_ntz\non_secure;..\..\..\..\..\common;..\..\..\..\..\cyclone_tcp;..\..\..\..\..\cyclone_ssh;..\..\..\..\..\cyclone_crypto
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x20040000 size 0x80000
  scatter file: .\stm32u575_flash.sct
  group Demo Sources
    ./: startup_stm32u575xx.s retarget.c
    ../src/: system_stm32u5xx.c stm32u5xx_it.c stm32u5xx_hal_timebase_tim.c main.c debug.c spi_driver.c ext_int_driver.c res.c
  group Demo Headers
    ../src/: os_port_config.h net_config.h ssh_config.h crypto_config.h FreeRTOSConfig.h stm32u5xx_hal_conf.h stm32u575i_eval_conf.h stm32u5xx_it.h spi_driver.h ext_int_driver.h
  group Common Sources
    ../../../../../common/: cpu_endian.c os_port_freertos.c date_time.c str.c resource_manager.c
  group Common Headers
    ../../../../../common/: cpu_endian.h os_port.h os_port_freertos.h date_time.h str.h resource_manager.h error.h debug.h
  group CycloneTCP Sources
    ../../../../../cyclone_tcp/core/: net.c net_mem.c net_misc.c nic.c ethernet.c ethernet_misc.c ip.c tcp.c tcp_fsm.c tcp_misc.c tcp_timer.c udp.c socket.c socket_misc.c bsd_socket.c bsd_socket_options.c bsd_socket_misc.c raw_socket.c
    ../../../../../cyclone_tcp/drivers/eth/: enc624j600_driver.c
    ../../../../../cyclone_tcp/ipv4/: arp.c arp_cache.c ipv4.c ipv4_frag.c ipv4_multicast.c ipv4_misc.c icmp.c
    ../../../../../cyclone_tcp/igmp/: igmp_host.c igmp_host_misc.c igmp_common.c igmp_debug.c
    ../../../../../cyclone_tcp/ipv6/: ipv6.c ipv6_frag.c ipv6_multicast.c ipv6_pmtu.c ipv6_misc.c icmpv6.c ndp.c ndp_cache.c ndp_misc.c slaac.c slaac_misc.c
    ../../../../../cyclone_tcp/mld/: mld_node.c mld_node_misc.c mld_common.c mld_debug.c
    ../../../../../cyclone_tcp/dns/: dns_cache.c dns_client.c dns_common.c dns_debug.c
    ../../../../../cyclone_tcp/mdns/: mdns_client.c mdns_responder.c mdns_responder_misc.c mdns_common.c
    ../../../../../cyclone_tcp/netbios/: nbns_client.c nbns_responder.c nbns_common.c
    ../../../../../cyclone_tcp/llmnr/: llmnr_client.c llmnr_responder.c llmnr_common.c
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.c dhcp_client_fsm.c dhcp_client_misc.c dhcp_common.c dhcp_debug.c
  group CycloneTCP Headers
    ../../../../../cyclone_tcp/core/: net.h net_mem.h net_misc.h nic.h ethernet.h ethernet_misc.h ip.h tcp.h tcp_fsm.h tcp_misc.h tcp_timer.h udp.h socket.h socket_misc.h bsd_socket.h bsd_socket_options.h bsd_socket_misc.h raw_socket.h
    ../../../../../cyclone_tcp/drivers/eth/: enc624j600_driver.h
    ../../../../../cyclone_tcp/ipv4/: arp.h arp_cache.h ipv4.h ipv4_frag.h ipv4_multicast.h ipv4_misc.h icmp.h
    ../../../../../cyclone_tcp/igmp/: igmp_host.h igmp_host_misc.h igmp_common.h igmp_debug.h
    ../../../../../cyclone_tcp/ipv6/: ipv6.h ipv6_frag.h ipv6_multicast.h ipv6_pmtu.h ipv6_misc.h icmpv6.h ndp.h ndp_cache.h ndp_misc.h slaac.h slaac_misc.h
    ../../../../../cyclone_tcp/mld/: mld_node.h mld_node_misc.h mld_common.h mld_debug.h
    ../../../../../cyclone_tcp/dns/: dns_cache.h dns_client.h dns_common.h dns_debug.h
    ../../../../../cyclone_tcp/mdns/: mdns_client.h mdns_responder.h mdns_responder_misc.h mdns_common.h
    ../../../../../cyclone_tcp/netbios/: nbns_client.h nbns_responder.h nbns_common.h
    ../../../../../cyclone_tcp/llmnr/: llmnr_client.h llmnr_responder.h llmnr_common.h
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.h dhcp_client_fsm.h dhcp_client_misc.h dhcp_common.h dhcp_debug.h
  group CycloneSSH Sources
    ../../../../../cyclone_ssh/ssh/: ssh.c ssh_server.c ssh_server_misc.c ssh_algorithms.c ssh_extensions.c ssh_transport.c ssh_kex.c ssh_kex_rsa.c ssh_kex_dh.c ssh_kex_dh_gex.c ssh_kex_ecdh.c ssh_kex_hybrid.c ssh_auth.c ssh_auth_password.c ssh_auth_public_key.c ssh_connection.c ssh_request.c ssh_channel.c ssh_packet.c ssh_key_material.c ssh_exchange_hash.c ssh_modp_groups.c ssh_key_import.c ssh_key_export.c ssh_key_parse.c ssh_key_format.c ssh_key_decrypt.c ssh_key_verify.c ssh_cert_import.c ssh_cert_export.c ssh_cert_parse.c ssh_cert_verify.c ssh_sign_generate.c ssh_sign_verify.c ssh_sign_misc.c ssh_misc.c
    ../../../../../cyclone_ssh/shell/: shell_server.c shell_server_pty.c shell_server_misc.c
  group CycloneSSH Headers
    ../../../../../cyclone_ssh/ssh/: ssh.h ssh_server.h ssh_server_misc.h ssh_algorithms.h ssh_extensions.h ssh_transport.h ssh_kex.h ssh_kex_rsa.h ssh_kex_dh.h ssh_kex_dh_gex.h ssh_kex_ecdh.h ssh_kex_hybrid.h ssh_auth.h ssh_auth_password.h ssh_auth_public_key.h ssh_connection.h ssh_request.h ssh_channel.h ssh_packet.h ssh_key_material.h ssh_exchange_hash.h ssh_modp_groups.h ssh_key_import.h ssh_key_export.h ssh_key_parse.h ssh_key_format.h ssh_key_decrypt.h ssh_key_verify.h ssh_cert_import.h ssh_cert_export.h ssh_cert_parse.h ssh_cert_verify.h ssh_sign_generate.h ssh_sign_verify.h ssh_sign_misc.h ssh_misc.h
    ../../../../../cyclone_ssh/shell/: shell_server.h shell_server_pty.h shell_server_misc.h
  group CycloneCRYPTO Sources
    ../../../../../cyclone_crypto/hardware/stm32u5xx/: stm32u5xx_crypto.c stm32u5xx_crypto_trng.c stm32u5xx_crypto_hash.c
    ../../../../../cyclone_crypto/hash/: md5.c ripemd160.c sha1.c sha256.c sha384.c sha512.c sha3_256.c sha3_512.c
    ../../../../../cyclone_crypto/mac/: hmac.c poly1305.c
    ../../../../../cyclone_crypto/cipher/: rc4.c cast128.c idea.c des.c des3.c aes.c blowfish.c twofish.c serpent.c camellia.c seed.c chacha.c
    ../../../../../cyclone_crypto/cipher_modes/: cbc.c ctr.c
    ../../../../../cyclone_crypto/aead/: gcm.c
    ../../../../../cyclone_crypto/pkc/: dh.c rsa.c rsa_misc.c dsa.c
    ../../../../../cyclone_crypto/ecc/: ec.c ec_curves.c ec_misc.c ecdh.c ecdsa.c eddsa.c curve25519.c curve448.c x25519.c x448.c ed25519.c ed448.c
    ../../../../../cyclone_crypto/pqc/: kem.c mlkem768.c mlkem1024.c sntrup761.c
    ../../../../../cyclone_crypto/mpi/: mpi.c
    ../../../../../cyclone_crypto/encoding/: base64.c asn1.c oid.c
    ../../../../../cyclone_crypto/pkix/: pem_import.c pem_key_import.c pem_decrypt.c pem_common.c pkcs5_decrypt.c pkcs5_common.c pkcs8_key_parse.c x509_key_parse.c x509_common.c
    ../../../../../cyclone_crypto/kdf/: pbkdf.c
    ../../../../../cyclone_crypto/xof/: keccak.c shake.c
    ../../../../../cyclone_crypto/rng/: hmac_drbg.c
  group CycloneCRYPTO Headers
    ../../../../../cyclone_crypto/core/: crypto.h
    ../../../../../cyclone_crypto/hardware/stm32u5xx/: stm32u5xx_crypto.h stm32u5xx_crypto_trng.h stm32u5xx_crypto_hash.h
    ../../../../../cyclone_crypto/hash/: md5.h ripemd160.h sha1.h sha256.h sha384.h sha512.h sha3_256.h sha3_512.h
    ../../../../../cyclone_crypto/mac/: hmac.h poly1305.h
    ../../../../../cyclone_crypto/cipher/: rc4.h cast128.h idea.h des.h des3.h aes.h blowfish.h twofish.h serpent.h camellia.h seed.h chacha.h
    ../../../../../cyclone_crypto/cipher_modes/: cbc.h ctr.h
    ../../../../../cyclone_crypto/aead/: gcm.h
    ../../../../../cyclone_crypto/pkc/: dh.h rsa.h rsa_misc.h dsa.h
    ../../../../../cyclone_crypto/ecc/: ec.h ec_curves.h ec_misc.h ecdh.h ecdsa.h eddsa.h curve25519.h curve448.h x25519.h x448.h ed25519.h ed448.h
    ../../../../../cyclone_crypto/pqc/: kem.h mlkem768.h mlkem1024.h sntrup761.h
    ../../../../../cyclone_crypto/mpi/: mpi.h
    ../../../../../cyclone_crypto/encoding/: base64.h asn1.h oid.h
    ../../../../../cyclone_crypto/pkix/: pem_import.h pem_key_import.h pem_decrypt.h pem_common.h pkcs5_decrypt.h pkcs5_common.h pkcs8_key_parse.h x509_key_parse.h x509_common.h
    ../../../../../cyclone_crypto/kdf/: pbkdf.h
    ../../../../../cyclone_crypto/xof/: keccak.h shake.h
    ../../../../../cyclone_crypto/rng/: hmac_drbg.h
  group FreeRTOS Sources
    ../../../../../third_party/freertos/portable/gcc/arm_cm33_ntz/non_secure/: port.c portasm.c
    ../../../../../third_party/freertos/: croutine.c list.c queue.c tasks.c timers.c
    ../../../../../third_party/freertos/portable/memmang/: heap_3.c
  group FreeRTOS Headers
    ../../../../../third_party/freertos/portable/gcc/arm_cm33_ntz/non_secure/: portmacro.h portasm.h
    ../../../../../third_party/freertos/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h task.h timers.h
  group STM32U575I-EV Sources
    ../../../../../third_party/st/boards2/stm32u575i_eval/: stm32u575i_eval.c stm32u575i_eval_audio.c stm32u575i_eval_bus.c stm32u575i_eval_camera.c stm32u575i_eval_eeprom.c stm32u575i_eval_io.c stm32u575i_eval_lcd.c stm32u575i_eval_motion_sensors.c stm32u575i_eval_ospi.c stm32u575i_eval_sd.c stm32u575i_eval_sram.c stm32u575i_eval_ts.c stm32u575i_eval_usbpd_pwr.c
    ../../../../../third_party/st/boards2/components/cs42l51/: cs42l51.c cs42l51_reg.c
    ../../../../../third_party/st/boards2/components/hx8347i/: hx8347i.c hx8347i_reg.c
    ../../../../../third_party/st/boards2/components/lsm6dso/: lsm6dso.c lsm6dso_reg.c
    ../../../../../third_party/st/boards2/components/m24lr64/: m24lr64.c
    ../../../../../third_party/st/boards2/components/mfxstm32l152/: mfxstm32l152.c mfxstm32l152_reg.c
    ../../../../../third_party/st/boards2/components/mx25lm51245g/: mx25lm51245g.c
    ../../../../../third_party/st/boards2/components/ov5640/: ov5640.c ov5640_reg.c
    ../../../../../third_party/st/boards2/components/sx8651/: sx8651.c sx8651_reg.c
    ../../../../../third_party/st/boards2/components/tcpp0203/: tcpp0203.c tcpp0203_reg.c
    ../../../../../third_party/st/boards2/utilities/lcd/: stm32_lcd.c
  group STM32U575I-EV Headers
    ../../../../../third_party/st/boards2/stm32u575i_eval/: stm32u575i_eval.h stm32u575i_eval_audio.h stm32u575i_eval_bus.h stm32u575i_eval_camera.h stm32u575i_eval_eeprom.h stm32u575i_eval_errno.h stm32u575i_eval_io.h stm32u575i_eval_lcd.h stm32u575i_eval_motion_sensors.h stm32u575i_eval_ospi.h stm32u575i_eval_sd.h stm32u575i_eval_sram.h stm32u575i_eval_ts.h stm32u575i_eval_usbpd_pwr.h
    ../../../../../third_party/st/boards2/components/cs42l51/: cs42l51.h cs42l51_reg.h
    ../../../../../third_party/st/boards2/components/hx8347i/: hx8347i.h hx8347i_reg.h
    ../../../../../third_party/st/boards2/components/lsm6dso/: lsm6dso.h lsm6dso_reg.h
    ../../../../../third_party/st/boards2/components/m24lr64/: m24lr64.h
    ../../../../../third_party/st/boards2/components/mfxstm32l152/: mfxstm32l152.h mfxstm32l152_reg.h
    ../../../../../third_party/st/boards2/components/mx25lm51245g/: mx25lm51245g.h
    ../../../../../third_party/st/boards2/components/ov5640/: ov5640.h ov5640_reg.h
    ../../../../../third_party/st/boards2/components/sx8651/: sx8651.h sx8651_reg.h
    ../../../../../third_party/st/boards2/components/tcpp0203/: tcpp0203.h tcpp0203_reg.h
    ../../../../../third_party/st/boards2/utilities/lcd/: stm32_lcd.h
  group STM32U5xx HAL Drivers Sources
    ../../../../../third_party/st/drivers/stm32u5xx_hal_driver/src/: stm32u5xx_hal.c stm32u5xx_hal_adc.c stm32u5xx_hal_adc_ex.c stm32u5xx_hal_comp.c stm32u5xx_hal_cordic.c stm32u5xx_hal_cortex.c stm32u5xx_hal_crc.c stm32u5xx_hal_crc_ex.c stm32u5xx_hal_cryp.c stm32u5xx_hal_cryp_ex.c stm32u5xx_hal_dac.c stm32u5xx_hal_dac_ex.c stm32u5xx_hal_dcache.c stm32u5xx_hal_dcmi.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma2d.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal_exti.c stm32u5xx_hal_fdcan.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_fmac.c stm32u5xx_hal_gpio.c stm32u5xx_hal_gtzc.c stm32u5xx_hal_hash.c stm32u5xx_hal_hash_ex.c stm32u5xx_hal_hcd.c stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_icache.c stm32u5xx_hal_irda.c stm32u5xx_hal_iwdg.c stm32u5xx_hal_lptim.c stm32u5xx_hal_mdf.c stm32u5xx_hal_mmc.c stm32u5xx_hal_mmc_ex.c stm32u5xx_hal_nand.c stm32u5xx_hal_nor.c stm32u5xx_hal_opamp.c stm32u5xx_hal_opamp_ex.c stm32u5xx_hal_ospi.c stm32u5xx_hal_otfdec.c stm32u5xx_hal_pcd.c stm32u5xx_hal_pcd_ex.c stm32u5xx_hal_pka.c stm32u5xx_hal_pssi.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_ramcfg.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_rng.c stm32u5xx_hal_rng_ex.c stm32u5xx_hal_rtc.c stm32u5xx_hal_rtc_ex.c stm32u5xx_hal_sai.c stm32u5xx_hal_sai_ex.c stm32u5xx_hal_sd.c stm32u5xx_hal_sd_ex.c stm32u5xx_hal_smartcard.c stm32u5xx_hal_smartcard_ex.c stm32u5xx_hal_smbus.c stm32u5xx_hal_smbus_ex.c stm32u5xx_hal_spi.c stm32u5xx_hal_spi_ex.c stm32u5xx_hal_sram.c stm32u5xx_hal_tim.c stm32u5xx_hal_tim_ex.c stm32u5xx_hal_tsc.c stm32u5xx_hal_uart.c stm32u5xx_hal_uart_ex.c stm32u5xx_hal_usart.c stm32u5xx_hal_usart_ex.c stm32u5xx_hal_wwdg.c stm32u5xx_ll_adc.c stm32u5xx_ll_comp.c stm32u5xx_ll_cordic.c stm32u5xx_ll_crc.c stm32u5xx_ll_crs.c stm32u5xx_ll_dac.c stm32u5xx_ll_dlyb.c stm32u5xx_ll_dma.c stm32u5xx_ll_dma2d.c stm32u5xx_ll_exti.c stm32u5xx_ll_fmac.c stm32u5xx_ll_fmc.c stm32u5xx_ll_gpio.c stm32u5xx_ll_i2c.c stm32u5xx_ll_icache.c stm32u5xx_ll_lpgpio.c stm32u5xx_ll_lptim.c stm32u5xx_ll_lpuart.c stm32u5xx_ll_opamp.c stm32u5xx_ll_pka.c stm32u5xx_ll_pwr.c stm32u5xx_ll_rcc.c stm32u5xx_ll_rng.c stm32u5xx_ll_rtc.c stm32u5xx_ll_sdmmc.c stm32u5xx_ll_spi.c stm32u5xx_ll_tim.c stm32u5xx_ll_ucpd.c stm32u5xx_ll_usart.c stm32u5xx_ll_usb.c stm32u5xx_ll_utils.c
  group STM32U5xx HAL Drivers Headers
    ../../../../../third_party/st/drivers/stm32u5xx_hal_driver/inc/: stm32u5xx_hal.h stm32u5xx_hal_adc.h stm32u5xx_hal_adc_ex.h stm32u5xx_hal_comp.h stm32u5xx_hal_cordic.h stm32u5xx_hal_cortex.h stm32u5xx_hal_crc.h stm32u5xx_hal_crc_ex.h stm32u5xx_hal_cryp.h stm32u5xx_hal_cryp_ex.h stm32u5xx_hal_dac.h stm32u5xx_hal_dac_ex.h stm32u5xx_hal_dcache.h stm32u5xx_hal_dcmi.h stm32u5xx_hal_def.h stm32u5xx_hal_dma.h stm32u5xx_hal_dma2d.h stm32u5xx_hal_dma_ex.h stm32u5xx_hal_exti.h stm32u5xx_hal_fdcan.h stm32u5xx_hal_flash.h stm32u5xx_hal_flash_ex.h stm32u5xx_hal_fmac.h stm32u5xx_hal_gpio.h stm32u5xx_hal_gpio_ex.h stm32u5xx_hal_gtzc.h stm32u5xx_hal_hash.h stm32u5xx_hal_hash_ex.h stm32u5xx_hal_hcd.h stm32u5xx_hal_i2c.h stm32u5xx_hal_i2c_ex.h stm32u5xx_hal_icache.h stm32u5xx_hal_irda.h stm32u5xx_hal_irda_ex.h stm32u5xx_hal_iwdg.h stm32u5xx_hal_lptim.h stm32u5xx_hal_mdf.h stm32u5xx_hal_mmc.h stm32u5xx_hal_mmc_ex.h stm32u5xx_hal_nand.h stm32u5xx_hal_nor.h stm32u5xx_hal_opamp.h stm32u5xx_hal_opamp_ex.h stm32u5xx_hal_ospi.h stm32u5xx_hal_otfdec.h stm32u5xx_hal_pcd.h stm32u5xx_hal_pcd_ex.h stm32u5xx_hal_pka.h stm32u5xx_hal_pssi.h stm32u5xx_hal_pwr.h stm32u5xx_hal_pwr_ex.h stm32u5xx_hal_ramcfg.h stm32u5xx_hal_rcc.h stm32u5xx_hal_rcc_ex.h stm32u5xx_hal_rng.h stm32u5xx_hal_rng_ex.h stm32u5xx_hal_rtc.h stm32u5xx_hal_rtc_ex.h stm32u5xx_hal_sai.h stm32u5xx_hal_sai_ex.h stm32u5xx_hal_sd.h stm32u5xx_hal_sd_ex.h stm32u5xx_hal_smartcard.h stm32u5xx_hal_smartcard_ex.h stm32u5xx_hal_smbus.h stm32u5xx_hal_smbus_ex.h stm32u5xx_hal_spi.h stm32u5xx_hal_spi_ex.h stm32u5xx_hal_sram.h stm32u5xx_hal_tim.h stm32u5xx_hal_tim_ex.h stm32u5xx_hal_tsc.h stm32u5xx_hal_uart.h stm32u5xx_hal_uart_ex.h stm32u5xx_hal_usart.h stm32u5xx_hal_usart_ex.h stm32u5xx_hal_wwdg.h stm32u5xx_ll_adc.h stm32u5xx_ll_bus.h stm32u5xx_ll_comp.h stm32u5xx_ll_cordic.h stm32u5xx_ll_cortex.h stm32u5xx_ll_crc.h stm32u5xx_ll_crs.h stm32u5xx_ll_dac.h stm32u5xx_ll_dcache.h stm32u5xx_ll_dlyb.h stm32u5xx_ll_dma.h stm32u5xx_ll_dma2d.h stm32u5xx_ll_exti.h stm32u5xx_ll_fmac.h stm32u5xx_ll_fmc.h stm32u5xx_ll_gpio.h stm32u5xx_ll_i2c.h stm32u5xx_ll_icache.h stm32u5xx_ll_iwdg.h stm32u5xx_ll_lpgpio.h stm32u5xx_ll_lptim.h stm32u5xx_ll_lpuart.h stm32u5xx_ll_opamp.h stm32u5xx_ll_pka.h stm32u5xx_ll_pwr.h stm32u5xx_ll_rcc.h stm32u5xx_ll_rng.h stm32u5xx_ll_rtc.h stm32u5xx_ll_sdmmc.h stm32u5xx_ll_spi.h stm32u5xx_ll_system.h stm32u5xx_ll_tim.h stm32u5xx_ll_ucpd.h stm32u5xx_ll_usart.h stm32u5xx_ll_usb.h stm32u5xx_ll_utils.h stm32u5xx_ll_wwdg.h
target ssh_server_demo_sram (ARM-ADS)
  device: STM32U575AIIxQ STMicroelectronics
  pack: Keil.STM32U5xx_DFP.1.1.0
  cpu: as above
  output: ssh_server_demo_sram
  BeforeMake: as above
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: as above
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x20040000 size 0x80000
  scatter file: .\stm32u575_sram.sct
