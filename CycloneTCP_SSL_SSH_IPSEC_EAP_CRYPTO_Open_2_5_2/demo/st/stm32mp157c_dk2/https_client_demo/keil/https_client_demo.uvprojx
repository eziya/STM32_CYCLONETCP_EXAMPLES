# Keil uVision project https_client_demo.uvprojx, settings and files
target https_client_demo_engineering (ARM-ADS)
  device: STM32MP157CACx:Cortex-M4 STMicroelectronics
  pack: Keil.STM32MP1xx_DFP.1.1.0
  cpu: IRAM(0x10020000,0x00020000) IRAM2(0x10040000,0x00020000) IROM(0x10000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: https_client_demo_engineering
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32MP157Cxx CORE_CM4 USE_HAL_DRIVER USE_STM32MP15XX_DISCO
  c include: ..\src;..\..\..\..\..\third_party\cmsis\core\include;..\..\..\..\..\third_party\st\devices\stm32mp1xx;..\..\..\..\..\third_party\st\drivers\stm32mp1xx_hal_driver\inc;..\..\..\..\..\third_party\st\boards\stm32mp15xx_disco;..\..\..\..\..\third_party\freertos\include;..\..\..\..\..\third_party\freertos\portable\rvds\arm_cm4f;..\..\..\..\..\common;..\..\..\..\..\cyclone_tcp;..\..\..\..\..\cyclone_ssl;..\..\..\..\..\cyclone_crypto
  memory RVCT4: ROM 0x10000000 size 0x20000
  memory RVCT9: RAM 0x10020000 size 0x20000
  memory RVCT10: RAM 0x10040000 size 0x20000
  scatter file: .\stm32mp157_sram.sct
  group Demo Sources
    ./: startup_stm32mp15xx.s retarget.c
    ../src/: system_stm32mp1xx.c stm32mp1xx_it.c lock_resource.c main.c debug.c
  group Demo Headers
    ../src/: os_port_config.h net_config.h tls_config.h crypto_config.h FreeRTOSConfig.h stm32mp1xx_hal_conf.h stm32mp15xx_disco_conf.h stm32mp1xx_it.h lock_resource.h
  group Common Sources
    ../../../../../common/: cpu_endian.c os_port_freertos.c date_time.c str.c
  group Common Headers
    ../../../../../common/: cpu_endian.h os_port.h os_port_freertos.h date_time.h str.h error.h debug.h
  group CycloneTCP Sources
    ../../../../../cyclone_tcp/core/: net.c net_mem.c net_misc.c nic.c ethernet.c ethernet_misc.c ip.c tcp.c tcp_fsm.c tcp_misc.c tcp_timer.c udp.c socket.c socket_misc.c bsd_socket.c bsd_socket_options.c bsd_socket_misc.c raw_socket.c
    ../../../../../cyclone_tcp/drivers/mac/: stm32mp1xx_eth_driver.c
    ../../../../../cyclone_tcp/drivers/phy/: rtl8211f_driver.c
    ../../../../../cyclone_tcp/ipv4/: arp.c arp_cache.c ipv4.c ipv4_frag.c ipv4_multicast.c ipv4_misc.c icmp.c
    ../../../../../cyclone_tcp/igmp/: igmp_host.c igmp_host_misc.c igmp_common.c igmp_debug.c
    ../../../../../cyclone_tcp/ipv6/: ipv6.c ipv6_frag.c ipv6_multicast.c ipv6_pmtu.c ipv6_misc.c icmpv6.c ndp.c ndp_cache.c ndp_misc.c slaac.c slaac_misc.c
    ../../../../../cyclone_tcp/mld/: mld_node.c mld_node_misc.c mld_common.c mld_debug.c
    ../../../../../cyclone_tcp/dns/: dns_cache.c dns_client.c dns_common.c dns_debug.c
    ../../../../../cyclone_tcp/mdns/: mdns_client.c mdns_responder.c mdns_responder_misc.c mdns_common.c
    ../../../../../cyclone_tcp/netbios/: nbns_client.c nbns_responder.c nbns_common.c
    ../../../../../cyclone_tcp/llmnr/: llmnr_client.c llmnr_responder.c llmnr_common.c
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.c dhcp_client_fsm.c dhcp_client_misc.c dhcp_common.c dhcp_debug.c
    ../../../../../cyclone_tcp/http/: http_client.c http_client_transport.c http_client_misc.c http_common.c
  group CycloneTCP Headers
    ../../../../../cyclone_tcp/core/: net.h net_mem.h net_misc.h nic.h ethernet.h ethernet_misc.h ip.h tcp.h tcp_fsm.h tcp_misc.h tcp_timer.h udp.h socket.h socket_misc.h bsd_socket.h bsd_socket_options.h bsd_socket_misc.h raw_socket.h
    ../../../../../cyclone_tcp/drivers/mac/: stm32mp1xx_eth_driver.h
    ../../../../../cyclone_tcp/drivers/phy/: rtl8211f_driver.h
    ../../../../../cyclone_tcp/ipv4/: arp.h arp_cache.h ipv4.h ipv4_frag.h ipv4_multicast.h ipv4_misc.h icmp.h
    ../../../../../cyclone_tcp/igmp/: igmp_host.h igmp_host_misc.h igmp_common.h igmp_debug.h
    ../../../../../cyclone_tcp/ipv6/: ipv6.h ipv6_frag.h ipv6_multicast.h ipv6_pmtu.h ipv6_misc.h icmpv6.h ndp.h ndp_cache.h ndp_misc.h slaac.h slaac_misc.h
    ../../../../../cyclone_tcp/mld/: mld_node.h mld_node_misc.h mld_common.h mld_debug.h
    ../../../../../cyclone_tcp/dns/: dns_cache.h dns_client.h dns_common.h dns_debug.h
    ../../../../../cyclone_tcp/mdns/: mdns_client.h mdns_responder.h mdns_responder_misc.h mdns_common.h
    ../../../../../cyclone_tcp/netbios/: nbns_client.h nbns_responder.h nbns_common.h
    ../../../../../cyclone_tcp/llmnr/: llmnr_client.h llmnr_responder.h llmnr_common.h
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.h dhcp_client_fsm.h dhcp_client_misc.h dhcp_common.h dhcp_debug.h
    ../../../../../cyclone_tcp/http/: http_client.h http_client_transport.h http_client_misc.h http_common.h
  group CycloneSSL Sources
    ../../../../../cyclone_ssl/: tls.c tls_cipher_suites.c tls_handshake.c tls_client.c tls_client_fsm.c tls_client_extensions.c tls_client_misc.c tls_server.c tls_server_fsm.c tls_server_extensions.c tls_server_misc.c tls_common.c tls_extensions.c tls_certificate.c tls_sign_generate.c tls_sign_verify.c tls_sign_misc.c tls_key_material.c tls_transcript_hash.c tls_cache.c tls_ticket.c tls_ffdhe.c tls_record.c tls_record_encryption.c tls_record_decryption.c tls_misc.c tls13_client.c tls13_client_extensions.c tls13_client_misc.c tls13_server.c tls13_server_extensions.c tls13_server_misc.c tls13_common.c tls13_sign_generate.c tls13_sign_verify.c tls13_key_material.c tls13_ticket.c tls13_misc.c
  group CycloneSSL Headers
    ../../../../../cyclone_ssl/: tls.h tls_cipher_suites.h tls_handshake.h tls_client.h tls_client_fsm.h tls_client_extensions.h tls_client_misc.h tls_server.h tls_server_fsm.h tls_server_extensions.h tls_server_misc.h tls_common.h tls_extensions.h tls_certificate.h tls_sign_generate.h tls_sign_verify.h tls_sign_misc.h tls_key_material.h tls_transcript_hash.h tls_cache.h tls_ticket.h tls_ffdhe.h tls_record.h tls_record_encryption.h tls_record_decryption.h tls_misc.h tls13_client.h tls13_client_extensions.h tls13_client_misc.h tls13_server.h tls13_server_extensions.h tls13_server_misc.h tls13_common.h tls13_sign_generate.h tls13_sign_verify.h tls13_key_material.h tls13_ticket.h tls13_misc.h
  group CycloneCRYPTO Sources
    ../../../../../cyclone_crypto/hardware/stm32mp1xx/: stm32mp1xx_crypto.c stm32mp1xx_crypto_trng.c stm32mp1xx_crypto_hash.c stm32mp1xx_crypto_cipher.c
    ../../../../../cyclone_crypto/hash/: md5.c sha1.c sha224.c sha256.c sha384.c sha512.c
    ../../../../../cyclone_crypto/mac/: hmac.c poly1305.c
    ../../../../../cyclone_crypto/cipher/: rc4.c idea.c des.c des3.c aes.c camellia.c seed.c aria.c chacha.c
    ../../../../../cyclone_crypto/cipher_modes/: cbc.c
    ../../../../../cyclone_crypto/aead/: ccm.c gcm.c chacha20_poly1305.c
    ../../../../../cyclone_crypto/pkc/: dh.c rsa.c rsa_misc.c dsa.c
    ../../../../../cyclone_crypto/ecc/: ec.c ec_curves.c ec_misc.c ecdh.c ecdsa.c eddsa.c curve25519.c curve448.c x25519.c x448.c ed25519.c ed448.c
    ../../../../../cyclone_crypto/mpi/: mpi.c
    ../../../../../cyclone_crypto/encoding/: base64.c asn1.c oid.c
    ../../../../../cyclone_crypto/pkix/: pem_import.c pem_key_import.c pem_decrypt.c pem_common.c pkcs5_decrypt.c pkcs5_common.c pkcs8_key_parse.c x509_key_parse.c x509_cert_parse.c x509_cert_ext_parse.c x509_cert_validate.c x509_crl_parse.c x509_crl_ext_parse.c x509_crl_validate.c x509_sign_parse.c x509_sign_verify.c x509_common.c
    ../../../../../cyclone_crypto/kdf/: hkdf.c pbkdf.c
    ../../../../../cyclone_crypto/xof/: keccak.c shake.c
    ../../../../../cyclone_crypto/rng/: hmac_drbg.c
  group CycloneCRYPTO Headers
    ../../../../../cyclone_crypto/core/: crypto.h
    ../../../../../cyclone_crypto/hardware/stm32mp1xx/: stm32mp1xx_crypto.h stm32mp1xx_crypto_trng.h stm32mp1xx_crypto_hash.h stm32mp1xx_crypto_cipher.h
    ../../../../../cyclone_crypto/hash/: md5.h sha1.h sha224.h sha256.h sha384.h sha512.h
    ../../../../../cyclone_crypto/mac/: hmac.h poly1305.h
    ../../../../../cyclone_crypto/cipher/: rc4.h idea.h des.h des3.h aes.h camellia.h seed.h aria.h chacha.h
    ../../../../../cyclone_crypto/cipher_modes/: cbc.h
    ../../../../../cyclone_crypto/aead/: ccm.h gcm.h chacha20_poly1305.h
    ../../../../../cyclone_crypto/pkc/: dh.h rsa.h rsa_misc.h dsa.h
    ../../../../../cyclone_crypto/ecc/: ec.h ec_curves.h ec_misc.h ecdh.h ecdsa.h eddsa.h curve25519.h curve448.h x25519.h x448.h ed25519.h ed448.h
    ../../../../../cyclone_crypto/mpi/: mpi.h
    ../../../../../cyclone_crypto/encoding/: base64.h asn1.h oid.h
    ../../../../../cyclone_crypto/pkix/: pem_import.h pem_key_import.h pem_decrypt.h pem_common.h pkcs5_decrypt.h pkcs5_common.h pkcs8_key_parse.h x509_key_parse.h x509_cert_parse.h x509_cert_ext_parse.h x509_cert_validate.h x509_crl_parse.h x509_crl_ext_parse.h x509_crl_validate.h x509_sign_parse.h x509_sign_verify.h x509_common.h
    ../../../../../cyclone_crypto/kdf/: hkdf.h pbkdf.h
    ../../../../../cyclone_crypto/xof/: keccak.h shake.h
    ../../../../../cyclone_crypto/rng/: hmac_drbg.h
  group FreeRTOS Sources
    ../../../../../third_party/freertos/portable/rvds/arm_cm4f/: port.c
    ../../../../../third_party/freertos/: croutine.c list.c queue.c tasks.c timers.c
    ../../../../../third_party/freertos/portable/memmang/: heap_3.c
  group FreeRTOS Headers
    ../../../../../third_party/freertos/portable/rvds/arm_cm4f/: portmacro.h
    ../../../../../third_party/freertos/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h task.h timers.h
  group STM32MP157C-DK2 Sources
    ../../../../../third_party/st/boards/stm32mp15xx_disco/: stm32mp15xx_disco.c stm32mp15xx_disco_bus.c
  group STM32MP157C-DK2 Headers
    ../../../../../third_party/st/boards/stm32mp15xx_disco/: stm32mp15xx_disco.h stm32mp15xx_disco_bus.h stm32mp15xx_disco_errno.h stm32mp15xx_disco_stpmic1.h
  group STM32MP1xx HAL Drivers Sources
    ../../../../../third_party/st/drivers/stm32mp1xx_hal_driver/src/: stm32mp1xx_hal.c stm32mp1xx_hal_adc.c stm32mp1xx_hal_adc_ex.c stm32mp1xx_hal_cec.c stm32mp1xx_hal_cortex.c stm32mp1xx_hal_crc.c stm32mp1xx_hal_crc_ex.c stm32mp1xx_hal_cryp.c stm32mp1xx_hal_cryp_ex.c stm32mp1xx_hal_dac.c stm32mp1xx_hal_dac_ex.c stm32mp1xx_hal_dcmi.c stm32mp1xx_hal_dfsdm.c stm32mp1xx_hal_dfsdm_ex.c stm32mp1xx_hal_dma.c stm32mp1xx_hal_dma_ex.c stm32mp1xx_hal_exti.c stm32mp1xx_hal_fdcan.c stm32mp1xx_hal_gpio.c stm32mp1xx_hal_hash.c stm32mp1xx_hal_hash_ex.c stm32mp1xx_hal_hsem.c stm32mp1xx_hal_i2c.c stm32mp1xx_hal_i2c_ex.c stm32mp1xx_hal_ipcc.c stm32mp1xx_hal_lptim.c stm32mp1xx_hal_mdios.c stm32mp1xx_hal_mdma.c stm32mp1xx_hal_pwr.c stm32mp1xx_hal_pwr_ex.c stm32mp1xx_hal_qspi.c stm32mp1xx_hal_rcc.c stm32mp1xx_hal_rcc_ex.c stm32mp1xx_hal_rng.c stm32mp1xx_hal_sai.c stm32mp1xx_hal_sai_ex.c stm32mp1xx_hal_sd.c stm32mp1xx_hal_sd_ex.c stm32mp1xx_hal_smbus.c stm32mp1xx_hal_spdifrx.c stm32mp1xx_hal_spi.c stm32mp1xx_hal_spi_ex.c stm32mp1xx_hal_tim.c stm32mp1xx_hal_tim_ex.c stm32mp1xx_hal_uart.c stm32mp1xx_hal_uart_ex.c stm32mp1xx_hal_usart.c stm32mp1xx_hal_usart_ex.c stm32mp1xx_hal_wwdg.c stm32mp1xx_ll_adc.c stm32mp1xx_ll_delayblock.c stm32mp1xx_ll_gpio.c stm32mp1xx_ll_rcc.c stm32mp1xx_ll_sdmmc.c stm32mp1xx_ll_usart.c
  group STM32MP1xx HAL Drivers Headers
    ../../../../../third_party/st/drivers/stm32mp1xx_hal_driver/inc/: stm32mp1xx_hal.h stm32mp1xx_hal_adc.h stm32mp1xx_hal_adc_ex.h stm32mp1xx_hal_cec.h stm32mp1xx_hal_cortex.h stm32mp1xx_hal_crc.h stm32mp1xx_hal_crc_ex.h stm32mp1xx_hal_cryp.h stm32mp1xx_hal_cryp_ex.h stm32mp1xx_hal_dac.h stm32mp1xx_hal_dac_ex.h stm32mp1xx_hal_dcmi.h stm32mp1xx_hal_def.h stm32mp1xx_hal_dfsdm.h stm32mp1xx_hal_dfsdm_ex.h stm32mp1xx_hal_dma.h stm32mp1xx_hal_dma_ex.h stm32mp1xx_hal_exti.h stm32mp1xx_hal_fdcan.h stm32mp1xx_hal_gpio.h stm32mp1xx_hal_gpio_ex.h stm32mp1xx_hal_hash.h stm32mp1xx_hal_hash_ex.h stm32mp1xx_hal_hsem.h stm32mp1xx_hal_i2c.h stm32mp1xx_hal_i2c_ex.h stm32mp1xx_hal_ipcc.h stm32mp1xx_hal_lptim.h stm32mp1xx_hal_mdios.h stm32mp1xx_hal_mdma.h stm32mp1xx_hal_pwr.h stm32mp1xx_hal_pwr_ex.h stm32mp1xx_hal_qspi.h stm32mp1xx_hal_rcc.h stm32mp1xx_hal_rcc_ex.h stm32mp1xx_hal_rng.h stm32mp1xx_hal_sai.h stm32mp1xx_hal_sai_ex.h stm32mp1xx_hal_sd.h stm32mp1xx_hal_sd_ex.h stm32mp1xx_hal_smbus.h stm32mp1xx_hal_spdifrx.h stm32mp1xx_hal_spi.h stm32mp1xx_hal_spi_ex.h stm32mp1xx_hal_tim.h stm32mp1xx_hal_tim_ex.h stm32mp1xx_hal_uart.h stm32mp1xx_hal_uart_ex.h stm32mp1xx_hal_usart.h stm32mp1xx_hal_usart_ex.h stm32mp1xx_hal_wwdg.h stm32mp1xx_ll_adc.h stm32mp1xx_ll_bus.h stm32mp1xx_ll_delayblock.h stm32mp1xx_ll_gpio.h stm32mp1xx_ll_ipcc.h stm32mp1xx_ll_rcc.h stm32mp1xx_ll_sdmmc.h stm32mp1xx_ll_system.h stm32mp1xx_ll_usart.h stm32mp1xx_ll_utils.h
target https_client_demo_production (ARM-ADS)
  device: STM32MP157CACx:Cortex-M4 STMicroelectronics
  pack: Keil.STM32MP1xx_DFP.1.1.0
  cpu: as above
  output: https_client_demo_production
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32MP157Cxx CORE_CM4 USE_HAL_DRIVER USE_STM32MP15XX_DISCO
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x20000
  memory RVCT9: RAM 0x10020000 size 0x20000
  memory RVCT10: RAM 0x10040000 size 0x20000
  scatter file: .\stm32mp157_sram.sct
