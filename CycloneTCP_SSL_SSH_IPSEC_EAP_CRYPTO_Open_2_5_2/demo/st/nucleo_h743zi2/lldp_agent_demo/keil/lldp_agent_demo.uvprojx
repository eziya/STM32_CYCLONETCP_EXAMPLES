# Keil uVision project lldp_agent_demo.uvprojx, settings and files
target lldp_agent_demo_flash (ARM-ADS)
  device: STM32H743ZITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: lldp_agent_demo_flash
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32H743xx USE_HAL_DRIVER USE_NUCLEO_H743ZI2
  c include: ..\src;..\..\..\..\..\third_party\cmsis\core\include;..\..\..\..\..\third_party\st\devices\stm32h7xx;..\..\..\..\..\third_party\st\drivers\stm32h7xx_hal_driver\inc;..\..\..\..\..\third_party\st\boards\stm32h7xx_nucleo;..\..\..\..\..\third_party\freertos\include;..\..\..\..\..\third_party\freertos\portable\rvds\arm_cm7\r0p1;..\..\..\..\..\common;..\..\..\..\..\cyclone_tcp;..\..\..\..\..\cyclone_crypto
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\stm32h743_flash.sct
  group Demo Sources
    ./: startup_stm32h743xx.s retarget.c
    ../src/: system_stm32h7xx.c stm32h7xx_it.c main.c debug.c
  group Demo Headers
    ../src/: os_port_config.h net_config.h crypto_config.h FreeRTOSConfig.h stm32h7xx_hal_conf.h stm32h7xx_nucleo_conf.h stm32h7xx_it.h
  group Common Sources
    ../../../../../common/: cpu_endian.c os_port_freertos.c date_time.c str.c
  group Common Headers
    ../../../../../common/: cpu_endian.h os_port.h os_port_freertos.h date_time.h str.h error.h debug.h
  group CycloneTCP Sources
    ../../../../../cyclone_tcp/core/: net.c net_mem.c net_misc.c nic.c ethernet.c ethernet_misc.c ip.c tcp.c tcp_fsm.c tcp_misc.c tcp_timer.c udp.c socket.c socket_misc.c bsd_socket.c bsd_socket_options.c bsd_socket_misc.c raw_socket.c
    ../../../../../cyclone_tcp/drivers/mac/: stm32h7xx_eth_driver.c
    ../../../../../cyclone_tcp/drivers/phy/: lan8742_driver.c
    ../../../../../cyclone_tcp/lldp/: lldp.c lldp_ext_dot1.c lldp_ext_dot3.c lldp_ext_med.c lldp_mgmt.c lldp_fsm.c lldp_rx_fsm.c lldp_tx_fsm.c lldp_procedures.c lldp_tlv.c lldp_misc.c lldp_debug.c
    ../../../../../cyclone_tcp/ipv4/: arp.c arp_cache.c ipv4.c ipv4_frag.c ipv4_multicast.c ipv4_misc.c icmp.c
    ../../../../../cyclone_tcp/igmp/: igmp_host.c igmp_host_misc.c igmp_common.c igmp_debug.c
    ../../../../../cyclone_tcp/ipv6/: ipv6.c ipv6_frag.c ipv6_multicast.c ipv6_pmtu.c ipv6_misc.c icmpv6.c ndp.c ndp_cache.c ndp_misc.c slaac.c slaac_misc.c
    ../../../../../cyclone_tcp/mld/: mld_node.c mld_node_misc.c mld_common.c mld_debug.c
    ../../../../../cyclone_tcp/dns/: dns_cache.c dns_client.c dns_common.c dns_debug.c
    ../../../../../cyclone_tcp/mdns/: mdns_client.c mdns_responder.c mdns_responder_misc.c mdns_common.c
    ../../../../../cyclone_tcp/netbios/: nbns_client.c nbns_responder.c nbns_common.c
    ../../../../../cyclone_tcp/llmnr/: llmnr_client.c llmnr_responder.c llmnr_common.c
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.c dhcp_client_fsm.c dhcp_client_misc.c dhcp_common.c dhcp_debug.c
    ../../../../../cyclone_tcp/snmp/: snmp_agent.c snmp_agent_dispatch.c snmp_agent_message.c snmp_agent_pdu.c snmp_agent_object.c snmp_agent_trap.c snmp_agent_inform.c snmp_agent_usm.c snmp_agent_vacm.c snmp_agent_misc.c
    ../../../../../cyclone_tcp/mibs/: mib_common.c snmp_mib_module.c snmp_mib_impl.c lldp_mib_module.c lldp_mib_impl.c lldp_mib_impl_config.c lldp_mib_impl_stats.c lldp_mib_impl_local.c lldp_mib_impl_remote.c
  group CycloneTCP Headers
    ../../../../../cyclone_tcp/core/: net.h net_mem.h net_misc.h nic.h ethernet.h ethernet_misc.h ip.h tcp.h tcp_fsm.h tcp_misc.h tcp_timer.h udp.h socket.h socket_misc.h bsd_socket.h bsd_socket_options.h bsd_socket_misc.h raw_socket.h
    ../../../../../cyclone_tcp/drivers/mac/: stm32h7xx_eth_driver.h
    ../../../../../cyclone_tcp/drivers/phy/: lan8742_driver.h
    ../../../../../cyclone_tcp/lldp/: lldp.h lldp_ext_dot1.h lldp_ext_dot3.h lldp_ext_med.h lldp_mgmt.h lldp_fsm.h lldp_rx_fsm.h lldp_tx_fsm.h lldp_procedures.h lldp_tlv.h lldp_misc.h lldp_debug.h
    ../../../../../cyclone_tcp/ipv4/: arp.h arp_cache.h ipv4.h ipv4_frag.h ipv4_multicast.h ipv4_misc.h icmp.h
    ../../../../../cyclone_tcp/igmp/: igmp_host.h igmp_host_misc.h igmp_common.h igmp_debug.h
    ../../../../../cyclone_tcp/ipv6/: ipv6.h ipv6_frag.h ipv6_multicast.h ipv6_pmtu.h ipv6_misc.h icmpv6.h ndp.h ndp_cache.h ndp_misc.h slaac.h slaac_misc.h
    ../../../../../cyclone_tcp/mld/: mld_node.h mld_node_misc.h mld_common.h mld_debug.h
    ../../../../../cyclone_tcp/dns/: dns_cache.h dns_client.h dns_common.h dns_debug.h
    ../../../../../cyclone_tcp/mdns/: mdns_client.h mdns_responder.h mdns_responder_misc.h mdns_common.h
    ../../../../../cyclone_tcp/netbios/: nbns_client.h nbns_responder.h nbns_common.h
    ../../../../../cyclone_tcp/llmnr/: llmnr_client.h llmnr_responder.h llmnr_common.h
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.h dhcp_client_fsm.h dhcp_client_misc.h dhcp_common.h dhcp_debug.h
    ../../../../../cyclone_tcp/snmp/: snmp_agent.h snmp_agent_dispatch.h snmp_agent_message.h snmp_agent_pdu.h snmp_agent_object.h snmp_agent_trap.h snmp_agent_inform.h snmp_agent_usm.h snmp_agent_vacm.h snmp_agent_misc.h snmp_common.h
    ../../../../../cyclone_tcp/mibs/: mib_common.h snmp_mib_module.h snmp_mib_impl.h lldp_mib_module.h lldp_mib_impl.h lldp_mib_impl_config.h lldp_mib_impl_stats.h lldp_mib_impl_local.h lldp_mib_impl_remote.h
  group CycloneCRYPTO Sources
    ../../../../../cyclone_crypto/hash/: md5.c sha1.c
    ../../../../../cyclone_crypto/mac/: hmac.c
    ../../../../../cyclone_crypto/cipher/: des.c aes.c
    ../../../../../cyclone_crypto/cipher_modes/: cbc.c cfb.c
    ../../../../../cyclone_crypto/encoding/: asn1.c oid.c
  group CycloneCRYPTO Headers
    ../../../../../cyclone_crypto/core/: crypto.h
    ../../../../../cyclone_crypto/hash/: md5.h sha1.h
    ../../../../../cyclone_crypto/mac/: hmac.h
    ../../../../../cyclone_crypto/cipher/: des.h aes.h
    ../../../../../cyclone_crypto/cipher_modes/: cbc.h cfb.h
    ../../../../../cyclone_crypto/encoding/: asn1.h oid.h
  group FreeRTOS Sources
    ../../../../../third_party/freertos/portable/rvds/arm_cm7/r0p1/: port.c
    ../../../../../third_party/freertos/: croutine.c list.c queue.c tasks.c timers.c
    ../../../../../third_party/freertos/portable/memmang/: heap_3.c
  group FreeRTOS Headers
    ../../../../../third_party/freertos/portable/rvds/arm_cm7/r0p1/: portmacro.h
    ../../../../../third_party/freertos/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h task.h timers.h
  group Nucleo-H743ZI2 Sources
    ../../../../../third_party/st/boards/stm32h7xx_nucleo/: stm32h7xx_nucleo.c
  group Nucleo-H743ZI2 Headers
    ../../../../../third_party/st/boards/stm32h7xx_nucleo/: stm32h7xx_nucleo.h stm32h7xx_nucleo_errno.h
  group STM32H7xx HAL Drivers Sources
    ../../../../../third_party/st/drivers/stm32h7xx_hal_driver/src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cec.c stm32h7xx_hal_comp.c stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_cryp.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_dac.c stm32h7xx_hal_dac_ex.c stm32h7xx_hal_dcmi.c stm32h7xx_hal_dfsdm.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_dsi.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hash.c stm32h7xx_hal_hash_ex.c stm32h7xx_hal_hcd.c stm32h7xx_hal_hrtim.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_i2s.c stm32h7xx_hal_i2s_ex.c stm32h7xx_hal_irda.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_jpeg.c stm32h7xx_hal_lptim.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_mdios.c stm32h7xx_hal_mdma.c stm32h7xx_hal_mmc.c stm32h7xx_hal_mmc_ex.c stm32h7xx_hal_nand.c stm32h7xx_hal_nor.c stm32h7xx_hal_opamp.c stm32h7xx_hal_opamp_ex.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_ramecc.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rng.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_sai.c stm32h7xx_hal_sai_ex.c stm32h7xx_hal_sd.c stm32h7xx_hal_sdram.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_smartcard.c stm32h7xx_hal_smartcard_ex.c stm32h7xx_hal_smbus.c stm32h7xx_hal_spdifrx.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_sram.c stm32h7xx_hal_swpmi.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_usart_ex.c stm32h7xx_hal_wwdg.c stm32h7xx_ll_adc.c stm32h7xx_ll_bdma.c stm32h7xx_ll_comp.c stm32h7xx_ll_crc.c stm32h7xx_ll_dac.c stm32h7xx_ll_delayblock.c stm32h7xx_ll_dma.c stm32h7xx_ll_dma2d.c stm32h7xx_ll_exti.c stm32h7xx_ll_fmc.c stm32h7xx_ll_gpio.c stm32h7xx_ll_hrtim.c stm32h7xx_ll_i2c.c stm32h7xx_ll_lptim.c stm32h7xx_ll_lpuart.c stm32h7xx_ll_mdma.c stm32h7xx_ll_opamp.c stm32h7xx_ll_pwr.c stm32h7xx_ll_rcc.c stm32h7xx_ll_rng.c stm32h7xx_ll_rtc.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_spi.c stm32h7xx_ll_swpmi.c stm32h7xx_ll_tim.c stm32h7xx_ll_usart.c stm32h7xx_ll_usb.c
  group STM32H7xx HAL Drivers Headers
    ../../../../../third_party/st/drivers/stm32h7xx_hal_driver/inc/: stm32h7xx_hal.h stm32h7xx_hal_adc.h stm32h7xx_hal_adc_ex.h stm32h7xx_hal_cec.h stm32h7xx_hal_comp.h stm32h7xx_hal_cortex.h stm32h7xx_hal_crc.h stm32h7xx_hal_crc_ex.h stm32h7xx_hal_cryp.h stm32h7xx_hal_cryp_ex.h stm32h7xx_hal_dac.h stm32h7xx_hal_dac_ex.h stm32h7xx_hal_dcmi.h stm32h7xx_hal_def.h stm32h7xx_hal_dfsdm.h stm32h7xx_hal_dma.h stm32h7xx_hal_dma_ex.h stm32h7xx_hal_dma2d.h stm32h7xx_hal_dsi.h stm32h7xx_hal_exti.h stm32h7xx_hal_fdcan.h stm32h7xx_hal_flash.h stm32h7xx_hal_flash_ex.h stm32h7xx_hal_gpio.h stm32h7xx_hal_gpio_ex.h stm32h7xx_hal_hash.h stm32h7xx_hal_hash_ex.h stm32h7xx_hal_hcd.h stm32h7xx_hal_hrtim.h stm32h7xx_hal_hsem.h stm32h7xx_hal_i2c.h stm32h7xx_hal_i2c_ex.h stm32h7xx_hal_i2s.h stm32h7xx_hal_i2s_ex.h stm32h7xx_hal_irda.h stm32h7xx_hal_irda_ex.h stm32h7xx_hal_iwdg.h stm32h7xx_hal_jpeg.h stm32h7xx_hal_lptim.h stm32h7xx_hal_ltdc.h stm32h7xx_hal_ltdc_ex.h stm32h7xx_hal_mdios.h stm32h7xx_hal_mdma.h stm32h7xx_hal_mmc.h stm32h7xx_hal_mmc_ex.h stm32h7xx_hal_nand.h stm32h7xx_hal_nor.h stm32h7xx_hal_opamp.h stm32h7xx_hal_opamp_ex.h stm32h7xx_hal_pcd.h stm32h7xx_hal_pcd_ex.h stm32h7xx_hal_pwr.h stm32h7xx_hal_pwr_ex.h stm32h7xx_hal_qspi.h stm32h7xx_hal_ramecc.h stm32h7xx_hal_rcc.h stm32h7xx_hal_rcc_ex.h stm32h7xx_hal_rng.h stm32h7xx_hal_rtc.h stm32h7xx_hal_rtc_ex.h stm32h7xx_hal_sai.h stm32h7xx_hal_sai_ex.h stm32h7xx_hal_sd.h stm32h7xx_hal_sdram.h stm32h7xx_hal_sd_ex.h stm32h7xx_hal_smartcard.h stm32h7xx_hal_smartcard_ex.h stm32h7xx_hal_smbus.h stm32h7xx_hal_spdifrx.h stm32h7xx_hal_spi.h stm32h7xx_hal_spi_ex.h stm32h7xx_hal_sram.h stm32h7xx_hal_swpmi.h stm32h7xx_hal_tim.h stm32h7xx_hal_tim_ex.h stm32h7xx_hal_uart.h stm32h7xx_hal_uart_ex.h stm32h7xx_hal_usart.h stm32h7xx_hal_usart_ex.h stm32h7xx_hal_wwdg.h stm32h7xx_ll_adc.h stm32h7xx_ll_bdma.h stm32h7xx_ll_bus.h stm32h7xx_ll_comp.h stm32h7xx_ll_cortex.h stm32h7xx_ll_crc.h stm32h7xx_ll_dac.h stm32h7xx_ll_delayblock.h stm32h7xx_ll_dma.h stm32h7xx_ll_dma2d.h stm32h7xx_ll_dmamux.h stm32h7xx_ll_exti.h stm32h7xx_ll_fmc.h stm32h7xx_ll_gpio.h stm32h7xx_ll_hrtim.h stm32h7xx_ll_hsem.h stm32h7xx_ll_i2c.h stm32h7xx_ll_iwdg.h stm32h7xx_ll_lptim.h stm32h7xx_ll_lpuart.h stm32h7xx_ll_mdma.h stm32h7xx_ll_opamp.h stm32h7xx_ll_pwr.h stm32h7xx_ll_rcc.h stm32h7xx_ll_rng.h stm32h7xx_ll_rtc.h stm32h7xx_ll_sdmmc.h stm32h7xx_ll_spi.h stm32h7xx_ll_swpmi.h stm32h7xx_ll_system.h stm32h7xx_ll_tim.h stm32h7xx_ll_usart.h stm32h7xx_ll_usb.h stm32h7xx_ll_wwdg.h
target lldp_agent_demo_sram (ARM-ADS)
  device: STM32H743ZITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.3.0
  cpu: as above
  output: lldp_agent_demo_sram
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32H743xx USE_HAL_DRIVER USE_NUCLEO_H743ZI2
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\stm32h743_sram.sct
