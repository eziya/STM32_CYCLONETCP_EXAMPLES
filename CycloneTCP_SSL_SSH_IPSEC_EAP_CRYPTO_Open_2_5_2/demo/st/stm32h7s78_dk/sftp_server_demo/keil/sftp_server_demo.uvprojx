# Keil uVision project sftp_server_demo.uvprojx, settings and files
target sftp_server_demo_flash (ARM-ADS)
  device: STM32H7S7L8Hx STMicroelectronics
  pack: Keil.STM32H7RSxx_DFP.1.0.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: sftp_server_demo_flash
  BeforeMake: ..\..\..\..\..\utils\ResourceCompiler\bin\rc.exe ..\resources\ ..\src\res.c
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32H7S7xx USE_HAL_DRIVER USE_STM32H7S78_DK
  c include: ..\src;..\..\..\..\..\third_party\cmsis\core\include;..\..\..\..\..\third_party\st\devices\stm32h7rsxx;..\..\..\..\..\third_party\st\drivers\stm32h7rsxx_hal_driver\inc;..\..\..\..\..\third_party\st\boards2\stm32h7s78_discovery;..\..\..\..\..\third_party\st\boards2\components\common;..\..\..\..\..\third_party\st\boards2\utilities\lcd;..\..\..\..\..\third_party\freertos\include;..\..\..\..\..\third_party\freertos\portable\rvds\arm_cm7\r0p1;..\..\..\..\..\third_party\fatfs;..\..\..\..\..\common;..\..\..\..\..\cyclone_tcp;..\..\..\..\..\cyclone_ssh;..\..\..\..\..\cyclone_crypto
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\stm32h7s7_flash.sct
  group Demo Sources
    ./: startup_stm32h7s7xx.s retarget.c
    ../src/: system_stm32h7rsxx.c stm32h7rsxx_it.c main.c diskio.c smi_driver.c debug.c res.c
  group Demo Headers
    ../src/: os_port_config.h fs_port_config.h net_config.h ssh_config.h crypto_config.h FreeRTOSConfig.h ffconf.h stm32h7rsxx_hal_conf.h stm32h7s78_discovery_conf.h aps256xx_conf.h gt911_conf.h mx66uw1g45g_conf.h stm32h7rsxx_it.h smi_driver.h
  group Common Sources
    ../../../../../common/: cpu_endian.c os_port_freertos.c fs_port_fatfs.c date_time.c str.c path.c resource_manager.c
  group Common Headers
    ../../../../../common/: cpu_endian.h os_port.h os_port_freertos.h fs_port.h fs_port_fatfs.h date_time.h str.h path.h resource_manager.h error.h debug.h
  group CycloneTCP Sources
    ../../../../../cyclone_tcp/core/: net.c net_mem.c net_misc.c nic.c ethernet.c ethernet_misc.c ip.c tcp.c tcp_fsm.c tcp_misc.c tcp_timer.c udp.c socket.c socket_misc.c bsd_socket.c bsd_socket_options.c bsd_socket_misc.c raw_socket.c
    ../../../../../cyclone_tcp/drivers/mac/: stm32h7rsxx_eth_driver.c
    ../../../../../cyclone_tcp/drivers/phy/: lan8742_driver.c
    ../../../../../cyclone_tcp/ipv4/: arp.c arp_cache.c ipv4.c ipv4_frag.c ipv4_multicast.c ipv4_misc.c icmp.c
    ../../../../../cyclone_tcp/igmp/: igmp_host.c igmp_host_misc.c igmp_common.c igmp_debug.c
    ../../../../../cyclone_tcp/ipv6/: ipv6.c ipv6_frag.c ipv6_multicast.c ipv6_pmtu.c ipv6_misc.c icmpv6.c ndp.c ndp_cache.c ndp_misc.c slaac.c slaac_misc.c
    ../../../../../cyclone_tcp/mld/: mld_node.c mld_node_misc.c mld_common.c mld_debug.c
    ../../../../../cyclone_tcp/dns/: dns_cache.c dns_client.c dns_common.c dns_debug.c
    ../../../../../cyclone_tcp/mdns/: mdns_client.c mdns_responder.c mdns_responder_misc.c mdns_common.c
    ../../../../../cyclone_tcp/netbios/: nbns_client.c nbns_responder.c nbns_common.c
    ../../../../../cyclone_tcp/llmnr/: llmnr_client.c llmnr_responder.c llmnr_common.c
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.c dhcp_client_fsm.c dhcp_client_misc.c dhcp_common.c dhcp_debug.c
  group CycloneTCP Headers
    ../../../../../cyclone_tcp/core/: net.h net_mem.h net_misc.h nic.h ethernet.h ethernet_misc.h ip.h tcp.h tcp_fsm.h tcp_misc.h tcp_timer.h udp.h socket.h socket_misc.h bsd_socket.h bsd_socket_options.h bsd_socket_misc.h raw_socket.h
    ../../../../../cyclone_tcp/drivers/mac/: stm32h7rsxx_eth_driver.h
    ../../../../../cyclone_tcp/drivers/phy/: lan8742_driver.h
    ../../../../../cyclone_tcp/ipv4/: arp.h arp_cache.h ipv4.h ipv4_frag.h ipv4_multicast.h ipv4_misc.h icmp.h
    ../../../../../cyclone_tcp/igmp/: igmp_host.h igmp_host_misc.h igmp_common.h igmp_debug.h
    ../../../../../cyclone_tcp/ipv6/: ipv6.h ipv6_frag.h ipv6_multicast.h ipv6_pmtu.h ipv6_misc.h icmpv6.h ndp.h ndp_cache.h ndp_misc.h slaac.h slaac_misc.h
    ../../../../../cyclone_tcp/mld/: mld_node.h mld_node_misc.h mld_common.h mld_debug.h
    ../../../../../cyclone_tcp/dns/: dns_cache.h dns_client.h dns_common.h dns_debug.h
    ../../../../../cyclone_tcp/mdns/: mdns_client.h mdns_responder.h mdns_responder_misc.h mdns_common.h
    ../../../../../cyclone_tcp/netbios/: nbns_client.h nbns_responder.h nbns_common.h
    ../../../../../cyclone_tcp/llmnr/: llmnr_client.h llmnr_responder.h llmnr_common.h
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.h dhcp_client_fsm.h dhcp_client_misc.h dhcp_common.h dhcp_debug.h
  group CycloneSSH Sources
    ../../../../../cyclone_ssh/ssh/: ssh.c ssh_server.c ssh_server_misc.c ssh_algorithms.c ssh_extensions.c ssh_transport.c ssh_kex.c ssh_kex_rsa.c ssh_kex_dh.c ssh_kex_dh_gex.c ssh_kex_ecdh.c ssh_kex_hybrid.c ssh_auth.c ssh_auth_password.c ssh_auth_public_key.c ssh_connection.c ssh_request.c ssh_channel.c ssh_packet.c ssh_key_material.c ssh_exchange_hash.c ssh_modp_groups.c ssh_key_import.c ssh_key_export.c ssh_key_parse.c ssh_key_format.c ssh_key_decrypt.c ssh_key_verify.c ssh_cert_import.c ssh_cert_export.c ssh_cert_parse.c ssh_cert_verify.c ssh_sign_generate.c ssh_sign_verify.c ssh_sign_misc.c ssh_misc.c
    ../../../../../cyclone_ssh/sftp/: sftp_server.c sftp_server_file.c sftp_server_directory.c sftp_server_packet.c sftp_server_misc.c sftp_common.c
  group CycloneSSH Headers
    ../../../../../cyclone_ssh/ssh/: ssh.h ssh_server.h ssh_server_misc.h ssh_algorithms.h ssh_extensions.h ssh_transport.h ssh_kex.h ssh_kex_rsa.h ssh_kex_dh.h ssh_kex_dh_gex.h ssh_kex_ecdh.h ssh_kex_hybrid.h ssh_auth.h ssh_auth_password.h ssh_auth_public_key.h ssh_connection.h ssh_request.h ssh_channel.h ssh_packet.h ssh_key_material.h ssh_exchange_hash.h ssh_modp_groups.h ssh_key_import.h ssh_key_export.h ssh_key_parse.h ssh_key_format.h ssh_key_decrypt.h ssh_key_verify.h ssh_cert_import.h ssh_cert_export.h ssh_cert_parse.h ssh_cert_verify.h ssh_sign_generate.h ssh_sign_verify.h ssh_sign_misc.h ssh_misc.h
    ../../../../../cyclone_ssh/sftp/: sftp_server.h sftp_server_file.h sftp_server_directory.h sftp_server_packet.h sftp_server_misc.h sftp_common.h
  group CycloneCRYPTO Sources
    ../../../../../cyclone_crypto/hardware/stm32h7rsxx/: stm32h7rsxx_crypto.c stm32h7rsxx_crypto_trng.c stm32h7rsxx_crypto_hash.c stm32h7rsxx_crypto_cipher.c stm32h7rsxx_crypto_pkc.c
    ../../../../../cyclone_crypto/hash/: md5.c ripemd160.c sha1.c sha256.c sha384.c sha512.c sha3_256.c sha3_512.c
    ../../../../../cyclone_crypto/mac/: hmac.c poly1305.c
    ../../../../../cyclone_crypto/cipher/: rc4.c cast128.c idea.c des.c des3.c aes.c blowfish.c twofish.c serpent.c camellia.c seed.c chacha.c
    ../../../../../cyclone_crypto/cipher_modes/: cbc.c ctr.c
    ../../../../../cyclone_crypto/aead/: gcm.c
    ../../../../../cyclone_crypto/pkc/: dh.c rsa.c rsa_misc.c dsa.c
    ../../../../../cyclone_crypto/ecc/: ec.c ec_curves.c ec_misc.c ecdh.c ecdsa.c eddsa.c curve25519.c curve448.c x25519.c x448.c ed25519.c ed448.c
    ../../../../../cyclone_crypto/pqc/: kem.c mlkem768.c mlkem1024.c sntrup761.c
    ../../../../../cyclone_crypto/mpi/: mpi.c
    ../../../../../cyclone_crypto/encoding/: base64.c asn1.c oid.c
    ../../../../../cyclone_crypto/pkix/: pem_import.c pem_key_import.c pem_decrypt.c pem_common.c pkcs5_decrypt.c pkcs5_common.c pkcs8_key_parse.c x509_key_parse.c x509_common.c
    ../../../../../cyclone_crypto/kdf/: pbkdf.c
    ../../../../../cyclone_crypto/xof/: keccak.c shake.c
    ../../../../../cyclone_crypto/rng/: hmac_drbg.c
  group CycloneCRYPTO Headers
    ../../../../../cyclone_crypto/core/: crypto.h
    ../../../../../cyclone_crypto/hardware/stm32h7rsxx/: stm32h7rsxx_crypto.h stm32h7rsxx_crypto_trng.h stm32h7rsxx_crypto_hash.h stm32h7rsxx_crypto_cipher.h stm32h7rsxx_crypto_pkc.h
    ../../../../../cyclone_crypto/hash/: md5.h ripemd160.h sha1.h sha256.h sha384.h sha512.h sha3_256.h sha3_512.h
    ../../../../../cyclone_crypto/mac/: hmac.h poly1305.h
    ../../../../../cyclone_crypto/cipher/: rc4.h cast128.h idea.h des.h des3.h aes.h blowfish.h twofish.h serpent.h camellia.h seed.h chacha.h
    ../../../../../cyclone_crypto/cipher_modes/: cbc.h ctr.h
    ../../../../../cyclone_crypto/aead/: gcm.h
    ../../../../../cyclone_crypto/pkc/: dh.h rsa.h rsa_misc.h dsa.h
    ../../../../../cyclone_crypto/ecc/: ec.h ec_curves.h ec_misc.h ecdh.h ecdsa.h eddsa.h curve25519.h curve448.h x25519.h x448.h ed25519.h ed448.h
    ../../../../../cyclone_crypto/pqc/: kem.h mlkem768.h mlkem1024.h sntrup761.h
    ../../../../../cyclone_crypto/mpi/: mpi.h
    ../../../../../cyclone_crypto/encoding/: base64.h asn1.h oid.h
    ../../../../../cyclone_crypto/pkix/: pem_import.h pem_key_import.h pem_decrypt.h pem_common.h pkcs5_decrypt.h pkcs5_common.h pkcs8_key_parse.h x509_key_parse.h x509_common.h
    ../../../../../cyclone_crypto/kdf/: pbkdf.h
    ../../../../../cyclone_crypto/xof/: keccak.h shake.h
    ../../../../../cyclone_crypto/rng/: hmac_drbg.h
  group FreeRTOS Sources
    ../../../../../third_party/freertos/portable/rvds/arm_cm7/r0p1/: port.c
    ../../../../../third_party/freertos/: croutine.c list.c queue.c tasks.c timers.c
    ../../../../../third_party/freertos/portable/memmang/: heap_3.c
  group FreeRTOS Headers
    ../../../../../third_party/freertos/portable/rvds/arm_cm7/r0p1/: portmacro.h
    ../../../../../third_party/freertos/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h task.h timers.h
  group FatFs Sources
    ../../../../../third_party/fatfs/: ff.c
    ../../../../../third_party/fatfs/option/: unicode.c
  group FatFs Headers
    ../../../../../third_party/fatfs/: diskio.h ff.h integer.h
  group STM32H7S78-DK Sources
    ../../../../../third_party/st/boards2/stm32h7s78_discovery/: stm32h7s78_discovery.c stm32h7s78_discovery_audio.c stm32h7s78_discovery_bus.c stm32h7s78_discovery_lcd.c stm32h7s78_discovery_sd.c stm32h7s78_discovery_ts.c stm32h7s78_discovery_usbpd_pwr.c stm32h7s78_discovery_xspi.c
    ../../../../../third_party/st/boards2/components/aps256xx/: aps256xx.c
    ../../../../../third_party/st/boards2/components/gt911/: gt911.c gt911_reg.c
    ../../../../../third_party/st/boards2/components/mx66uw1g45g/: mx66uw1g45g.c
    ../../../../../third_party/st/boards2/components/tcpp0203/: tcpp0203.c tcpp0203_reg.c
    ../../../../../third_party/st/boards2/components/wm8904/: wm8904.c wm8904_reg.c
    ../../../../../third_party/st/boards2/utilities/lcd/: stm32_lcd.c
  group STM32H7S78-DK Headers
    ../../../../../third_party/st/boards2/stm32h7s78_discovery/: stm32h7s78_discovery.h stm32h7s78_discovery_audio.h stm32h7s78_discovery_bus.h stm32h7s78_discovery_errno.h stm32h7s78_discovery_lcd.h stm32h7s78_discovery_sd.h stm32h7s78_discovery_ts.h stm32h7s78_discovery_usbpd_pwr.h stm32h7s78_discovery_xspi.h
    ../../../../../third_party/st/boards2/components/aps256xx/: aps256xx.h
    ../../../../../third_party/st/boards2/components/gt911/: gt911.h gt911_reg.h
    ../../../../../third_party/st/boards2/components/mx66uw1g45g/: mx66uw1g45g.h
    ../../../../../third_party/st/boards2/components/rk050hr18/: rk050hr18.h
    ../../../../../third_party/st/boards2/components/tcpp0203/: tcpp0203.h tcpp0203_reg.h
    ../../../../../third_party/st/boards2/components/wm8904/: wm8904.h wm8904_reg.h
    ../../../../../third_party/st/boards2/utilities/lcd/: stm32_lcd.h
  group STM32H7xx HAL Drivers Sources
    ../../../../../third_party/st/drivers/stm32h7rsxx_hal_driver/src/: stm32h7rsxx_hal.c stm32h7rsxx_hal_adc.c stm32h7rsxx_hal_adc_ex.c stm32h7rsxx_hal_cec.c stm32h7rsxx_hal_cordic.c stm32h7rsxx_hal_cortex.c stm32h7rsxx_hal_crc.c stm32h7rsxx_hal_crc_ex.c stm32h7rsxx_hal_cryp.c stm32h7rsxx_hal_cryp_ex.c stm32h7rsxx_hal_dcmipp.c stm32h7rsxx_hal_dma.c stm32h7rsxx_hal_dma2d.c stm32h7rsxx_hal_dma_ex.c stm32h7rsxx_hal_dts.c stm32h7rsxx_hal_eth.c stm32h7rsxx_hal_eth_ex.c stm32h7rsxx_hal_exti.c stm32h7rsxx_hal_fdcan.c stm32h7rsxx_hal_flash.c stm32h7rsxx_hal_flash_ex.c stm32h7rsxx_hal_gfxmmu.c stm32h7rsxx_hal_gfxtim.c stm32h7rsxx_hal_gpio.c stm32h7rsxx_hal_gpu2d.c stm32h7rsxx_hal_hash.c stm32h7rsxx_hal_hcd.c stm32h7rsxx_hal_i2c.c stm32h7rsxx_hal_i2c_ex.c stm32h7rsxx_hal_i2s.c stm32h7rsxx_hal_i2s_ex.c stm32h7rsxx_hal_i3c.c stm32h7rsxx_hal_icache.c stm32h7rsxx_hal_irda.c stm32h7rsxx_hal_iwdg.c stm32h7rsxx_hal_jpeg.c stm32h7rsxx_hal_lptim.c stm32h7rsxx_hal_ltdc.c stm32h7rsxx_hal_ltdc_ex.c stm32h7rsxx_hal_mce.c stm32h7rsxx_hal_mdf.c stm32h7rsxx_hal_mdios.c stm32h7rsxx_hal_mmc.c stm32h7rsxx_hal_mmc_ex.c stm32h7rsxx_hal_nand.c stm32h7rsxx_hal_nor.c stm32h7rsxx_hal_pcd.c stm32h7rsxx_hal_pcd_ex.c stm32h7rsxx_hal_pka.c stm32h7rsxx_hal_pssi.c stm32h7rsxx_hal_pwr.c stm32h7rsxx_hal_pwr_ex.c stm32h7rsxx_hal_ramecc.c stm32h7rsxx_hal_rcc.c stm32h7rsxx_hal_rcc_ex.c stm32h7rsxx_hal_rng.c stm32h7rsxx_hal_rng_ex.c stm32h7rsxx_hal_rtc.c stm32h7rsxx_hal_rtc_ex.c stm32h7rsxx_hal_sai.c stm32h7rsxx_hal_sai_ex.c stm32h7rsxx_hal_sd.c stm32h7rsxx_hal_sdram.c stm32h7rsxx_hal_sd_ex.c stm32h7rsxx_hal_smartcard.c stm32h7rsxx_hal_smartcard_ex.c stm32h7rsxx_hal_smbus.c stm32h7rsxx_hal_smbus_ex.c stm32h7rsxx_hal_spdifrx.c stm32h7rsxx_hal_spi.c stm32h7rsxx_hal_spi_ex.c stm32h7rsxx_hal_sram.c stm32h7rsxx_hal_tim.c stm32h7rsxx_hal_tim_ex.c stm32h7rsxx_hal_uart.c stm32h7rsxx_hal_uart_ex.c stm32h7rsxx_hal_usart.c stm32h7rsxx_hal_usart_ex.c stm32h7rsxx_hal_wwdg.c stm32h7rsxx_hal_xspi.c stm32h7rsxx_ll_adc.c stm32h7rsxx_ll_cordic.c stm32h7rsxx_ll_crc.c stm32h7rsxx_ll_crs.c stm32h7rsxx_ll_dlyb.c stm32h7rsxx_ll_dma.c stm32h7rsxx_ll_dma2d.c stm32h7rsxx_ll_exti.c stm32h7rsxx_ll_fmc.c stm32h7rsxx_ll_gpio.c stm32h7rsxx_ll_i2c.c stm32h7rsxx_ll_i3c.c stm32h7rsxx_ll_lptim.c stm32h7rsxx_ll_lpuart.c stm32h7rsxx_ll_pka.c stm32h7rsxx_ll_pwr.c stm32h7rsxx_ll_rcc.c stm32h7rsxx_ll_rng.c stm32h7rsxx_ll_rtc.c stm32h7rsxx_ll_sdmmc.c stm32h7rsxx_ll_spi.c stm32h7rsxx_ll_tim.c stm32h7rsxx_ll_ucpd.c stm32h7rsxx_ll_usart.c stm32h7rsxx_ll_usb.c stm32h7rsxx_util_i3c.c
  group STM32H7xx HAL Drivers Headers
    ../../../../../third_party/st/drivers/stm32h7rsxx_hal_driver/inc/: stm32h7rsxx_hal.h stm32h7rsxx_hal_adc.h stm32h7rsxx_hal_adc_ex.h stm32h7rsxx_hal_cec.h stm32h7rsxx_hal_cordic.h stm32h7rsxx_hal_cortex.h stm32h7rsxx_hal_crc.h stm32h7rsxx_hal_crc_ex.h stm32h7rsxx_hal_cryp.h stm32h7rsxx_hal_cryp_ex.h stm32h7rsxx_hal_dcmipp.h stm32h7rsxx_hal_def.h stm32h7rsxx_hal_dma.h stm32h7rsxx_hal_dma2d.h stm32h7rsxx_hal_dma_ex.h stm32h7rsxx_hal_dts.h stm32h7rsxx_hal_eth.h stm32h7rsxx_hal_eth_ex.h stm32h7rsxx_hal_exti.h stm32h7rsxx_hal_fdcan.h stm32h7rsxx_hal_flash.h stm32h7rsxx_hal_flash_ex.h stm32h7rsxx_hal_gfxmmu.h stm32h7rsxx_hal_gfxtim.h stm32h7rsxx_hal_gpio.h stm32h7rsxx_hal_gpio_ex.h stm32h7rsxx_hal_gpu2d.h stm32h7rsxx_hal_hash.h stm32h7rsxx_hal_hcd.h stm32h7rsxx_hal_i2c.h stm32h7rsxx_hal_i2c_ex.h stm32h7rsxx_hal_i2s.h stm32h7rsxx_hal_i2s_ex.h stm32h7rsxx_hal_i3c.h stm32h7rsxx_hal_icache.h stm32h7rsxx_hal_irda.h stm32h7rsxx_hal_irda_ex.h stm32h7rsxx_hal_iwdg.h stm32h7rsxx_hal_jpeg.h stm32h7rsxx_hal_lptim.h stm32h7rsxx_hal_ltdc.h stm32h7rsxx_hal_ltdc_ex.h stm32h7rsxx_hal_mce.h stm32h7rsxx_hal_mdf.h stm32h7rsxx_hal_mdios.h stm32h7rsxx_hal_mmc.h stm32h7rsxx_hal_mmc_ex.h stm32h7rsxx_hal_nand.h stm32h7rsxx_hal_nor.h stm32h7rsxx_hal_pcd.h stm32h7rsxx_hal_pcd_ex.h stm32h7rsxx_hal_pka.h stm32h7rsxx_hal_pssi.h stm32h7rsxx_hal_pwr.h stm32h7rsxx_hal_pwr_ex.h stm32h7rsxx_hal_ramecc.h stm32h7rsxx_hal_rcc.h stm32h7rsxx_hal_rcc_ex.h stm32h7rsxx_hal_rng.h stm32h7rsxx_hal_rng_ex.h stm32h7rsxx_hal_rtc.h stm32h7rsxx_hal_rtc_ex.h stm32h7rsxx_hal_sai.h stm32h7rsxx_hal_sai_ex.h stm32h7rsxx_hal_sd.h stm32h7rsxx_hal_sdram.h stm32h7rsxx_hal_sd_ex.h stm32h7rsxx_hal_smartcard.h stm32h7rsxx_hal_smartcard_ex.h stm32h7rsxx_hal_smbus.h stm32h7rsxx_hal_smbus_ex.h stm32h7rsxx_hal_spdifrx.h stm32h7rsxx_hal_spi.h stm32h7rsxx_hal_spi_ex.h stm32h7rsxx_hal_sram.h stm32h7rsxx_hal_tim.h stm32h7rsxx_hal_tim_ex.h stm32h7rsxx_hal_uart.h stm32h7rsxx_hal_uart_ex.h stm32h7rsxx_hal_usart.h stm32h7rsxx_hal_usart_ex.h stm32h7rsxx_hal_wwdg.h stm32h7rsxx_hal_xspi.h stm32h7rsxx_ll_adc.h stm32h7rsxx_ll_bus.h stm32h7rsxx_ll_cordic.h stm32h7rsxx_ll_cortex.h stm32h7rsxx_ll_crc.h stm32h7rsxx_ll_crs.h stm32h7rsxx_ll_dlyb.h stm32h7rsxx_ll_dma.h stm32h7rsxx_ll_dma2d.h stm32h7rsxx_ll_exti.h stm32h7rsxx_ll_fmc.h stm32h7rsxx_ll_gpio.h stm32h7rsxx_ll_i2c.h stm32h7rsxx_ll_i3c.h stm32h7rsxx_ll_icache.h stm32h7rsxx_ll_iwdg.h stm32h7rsxx_ll_lptim.h stm32h7rsxx_ll_lpuart.h stm32h7rsxx_ll_pka.h stm32h7rsxx_ll_pwr.h stm32h7rsxx_ll_rcc.h stm32h7rsxx_ll_rng.h stm32h7rsxx_ll_rtc.h stm32h7rsxx_ll_sdmmc.h stm32h7rsxx_ll_spi.h stm32h7rsxx_ll_system.h stm32h7rsxx_ll_tim.h stm32h7rsxx_ll_ucpd.h stm32h7rsxx_ll_usart.h stm32h7rsxx_ll_usb.h stm32h7rsxx_ll_utils.h stm32h7rsxx_ll_wwdg.h stm32h7rsxx_util_i3c.h
target sftp_server_demo_sram (ARM-ADS)
  device: STM32H7S7L8Hx STMicroelectronics
  pack: Keil.STM32H7RSxx_DFP.1.0.0
  cpu: as above
  output: sftp_server_demo_sram
  BeforeMake: as above
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32H7S7xx USE_HAL_DRIVER USE_STM32H7S78_DK
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\stm32h7s7_sram.sct
