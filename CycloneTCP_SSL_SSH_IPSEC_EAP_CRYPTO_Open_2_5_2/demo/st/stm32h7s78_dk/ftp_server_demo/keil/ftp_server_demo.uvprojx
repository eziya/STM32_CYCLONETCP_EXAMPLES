# Keil uVision project ftp_server_demo.uvprojx, settings and files
target ftp_server_demo_flash (ARM-ADS)
  device: STM32H7S7L8Hx STMicroelectronics
  pack: Keil.STM32H7RSxx_DFP.1.0.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: ftp_server_demo_flash
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32H7S7xx USE_HAL_DRIVER USE_STM32H7S78_DK
  c include: ..\src;..\..\..\..\..\third_party\cmsis\core\include;..\..\..\..\..\third_party\st\devices\stm32h7rsxx;..\..\..\..\..\third_party\st\drivers\stm32h7rsxx_hal_driver\inc;..\..\..\..\..\third_party\st\boards2\stm32h7s78_discovery;..\..\..\..\..\third_party\st\boards2\components\common;..\..\..\..\..\third_party\st\boards2\utilities\lcd;..\..\..\..\..\third_party\freertos\include;..\..\..\..\..\third_party\freertos\portable\rvds\arm_cm7\r0p1;..\..\..\..\..\third_party\fatfs;..\..\..\..\..\common;..\..\..\..\..\cyclone_tcp
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\stm32h7s7_flash.sct
  group Demo Sources
    ./: startup_stm32h7s7xx.s retarget.c
    ../src/: system_stm32h7rsxx.c stm32h7rsxx_it.c main.c diskio.c smi_driver.c debug.c
  group Demo Headers
    ../src/: os_port_config.h fs_port_config.h net_config.h FreeRTOSConfig.h ffconf.h stm32h7rsxx_hal_conf.h stm32h7s78_discovery_conf.h aps256xx_conf.h gt911_conf.h mx66uw1g45g_conf.h stm32h7rsxx_it.h smi_driver.h
  group Common Sources
    ../../../../../common/: cpu_endian.c os_port_freertos.c fs_port_fatfs.c date_time.c str.c path.c
  group Common Headers
    ../../../../../common/: cpu_endian.h os_port.h os_port_freertos.h fs_port.h fs_port_fatfs.h date_time.h str.h path.h error.h debug.h
  group CycloneTCP Sources
    ../../../../../cyclone_tcp/core/: net.c net_mem.c net_misc.c nic.c ethernet.c ethernet_misc.c ip.c tcp.c tcp_fsm.c tcp_misc.c tcp_timer.c udp.c socket.c socket_misc.c bsd_socket.c bsd_socket_options.c bsd_socket_misc.c raw_socket.c
    ../../../../../cyclone_tcp/drivers/mac/: stm32h7rsxx_eth_driver.c
    ../../../../../cyclone_tcp/drivers/phy/: lan8742_driver.c
    ../../../../../cyclone_tcp/ipv4/: arp.c arp_cache.c ipv4.c ipv4_frag.c ipv4_multicast.c ipv4_misc.c icmp.c
    ../../../../../cyclone_tcp/igmp/: igmp_host.c igmp_host_misc.c igmp_common.c igmp_debug.c
    ../../../../../cyclone_tcp/ipv6/: ipv6.c ipv6_frag.c ipv6_multicast.c ipv6_pmtu.c ipv6_misc.c icmpv6.c ndp.c ndp_cache.c ndp_misc.c slaac.c slaac_misc.c
    ../../../../../cyclone_tcp/mld/: mld_node.c mld_node_misc.c mld_common.c mld_debug.c
    ../../../../../cyclone_tcp/dns/: dns_cache.c dns_client.c dns_common.c dns_debug.c
    ../../../../../cyclone_tcp/mdns/: mdns_client.c mdns_responder.c mdns_responder_misc.c mdns_common.c
    ../../../../../cyclone_tcp/netbios/: nbns_client.c nbns_responder.c nbns_common.c
    ../../../../../cyclone_tcp/llmnr/: llmnr_client.c llmnr_responder.c llmnr_common.c
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.c dhcp_client_fsm.c dhcp_client_misc.c dhcp_common.c dhcp_debug.c
    ../../../../../cyclone_tcp/ftp/: ftp_server.c ftp_server_commands.c ftp_server_control.c ftp_server_data.c ftp_server_transport.c ftp_server_misc.c
  group CycloneTCP Headers
    ../../../../../cyclone_tcp/core/: net.h net_mem.h net_misc.h nic.h ethernet.h ethernet_misc.h ip.h tcp.h tcp_fsm.h tcp_misc.h tcp_timer.h udp.h socket.h socket_misc.h bsd_socket.h bsd_socket_options.h bsd_socket_misc.h raw_socket.h
    ../../../../../cyclone_tcp/drivers/mac/: stm32h7rsxx_eth_driver.h
    ../../../../../cyclone_tcp/drivers/phy/: lan8742_driver.h
    ../../../../../cyclone_tcp/ipv4/: arp.h arp_cache.h ipv4.h ipv4_frag.h ipv4_multicast.h ipv4_misc.h icmp.h
    ../../../../../cyclone_tcp/igmp/: igmp_host.h igmp_host_misc.h igmp_common.h igmp_debug.h
    ../../../../../cyclone_tcp/ipv6/: ipv6.h ipv6_frag.h ipv6_multicast.h ipv6_pmtu.h ipv6_misc.h icmpv6.h ndp.h ndp_cache.h ndp_misc.h slaac.h slaac_misc.h
    ../../../../../cyclone_tcp/mld/: mld_node.h mld_node_misc.h mld_common.h mld_debug.h
    ../../../../../cyclone_tcp/dns/: dns_cache.h dns_client.h dns_common.h dns_debug.h
    ../../../../../cyclone_tcp/mdns/: mdns_client.h mdns_responder.h mdns_responder_misc.h mdns_common.h
    ../../../../../cyclone_tcp/netbios/: nbns_client.h nbns_responder.h nbns_common.h
    ../../../../../cyclone_tcp/llmnr/: llmnr_client.h llmnr_responder.h llmnr_common.h
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.h dhcp_client_fsm.h dhcp_client_misc.h dhcp_common.h dhcp_debug.h
    ../../../../../cyclone_tcp/ftp/: ftp_server.h ftp_server_commands.h ftp_server_control.h ftp_server_data.h ftp_server_transport.h ftp_server_misc.h
  group FreeRTOS Sources
    ../../../../../third_party/freertos/portable/rvds/arm_cm7/r0p1/: port.c
    ../../../../../third_party/freertos/: croutine.c list.c queue.c tasks.c timers.c
    ../../../../../third_party/freertos/portable/memmang/: heap_3.c
  group FreeRTOS Headers
    ../../../../../third_party/freertos/portable/rvds/arm_cm7/r0p1/: portmacro.h
    ../../../../../third_party/freertos/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h task.h timers.h
  group FatFs Sources
    ../../../../../third_party/fatfs/: ff.c
    ../../../../../third_party/fatfs/option/: unicode.c
  group FatFs Headers
    ../../../../../third_party/fatfs/: diskio.h ff.h integer.h
  group STM32H7S78-DK Sources
    ../../../../../third_party/st/boards2/stm32h7s78_discovery/: stm32h7s78_discovery.c stm32h7s78_discovery_audio.c stm32h7s78_discovery_bus.c stm32h7s78_discovery_lcd.c stm32h7s78_discovery_sd.c stm32h7s78_discovery_ts.c stm32h7s78_discovery_usbpd_pwr.c stm32h7s78_discovery_xspi.c
    ../../../../../third_party/st/boards2/components/aps256xx/: aps256xx.c
    ../../../../../third_party/st/boards2/components/gt911/: gt911.c gt911_reg.c
    ../../../../../third_party/st/boards2/components/mx66uw1g45g/: mx66uw1g45g.c
    ../../../../../third_party/st/boards2/components/tcpp0203/: tcpp0203.c tcpp0203_reg.c
    ../../../../../third_party/st/boards2/components/wm8904/: wm8904.c wm8904_reg.c
    ../../../../../third_party/st/boards2/utilities/lcd/: stm32_lcd.c
  group STM32H7S78-DK Headers
    ../../../../../third_party/st/boards2/stm32h7s78_discovery/: stm32h7s78_discovery.h stm32h7s78_discovery_audio.h stm32h7s78_discovery_bus.h stm32h7s78_discovery_errno.h stm32h7s78_discovery_lcd.h stm32h7s78_discovery_sd.h stm32h7s78_discovery_ts.h stm32h7s78_discovery_usbpd_pwr.h stm32h7s78_discovery_xspi.h
    ../../../../../third_party/st/boards2/components/aps256xx/: aps256xx.h
    ../../../../../third_party/st/boards2/components/gt911/: gt911.h gt911_reg.h
    ../../../../../third_party/st/boards2/components/mx66uw1g45g/: mx66uw1g45g.h
    ../../../../../third_party/st/boards2/components/rk050hr18/: rk050hr18.h
    ../../../../../third_party/st/boards2/components/tcpp0203/: tcpp0203.h tcpp0203_reg.h
    ../../../../../third_party/st/boards2/components/wm8904/: wm8904.h wm8904_reg.h
    ../../../../../third_party/st/boards2/utilities/lcd/: stm32_lcd.h
  group STM32H7xx HAL Drivers Sources
    ../../../../../third_party/st/drivers/stm32h7rsxx_hal_driver/src/: stm32h7rsxx_hal.c stm32h7rsxx_hal_adc.c stm32h7rsxx_hal_adc_ex.c stm32h7rsxx_hal_cec.c stm32h7rsxx_hal_cordic.c stm32h7rsxx_hal_cortex.c stm32h7rsxx_hal_crc.c stm32h7rsxx_hal_crc_ex.c stm32h7rsxx_hal_cryp.c stm32h7rsxx_hal_cryp_ex.c stm32h7rsxx_hal_dcmipp.c stm32h7rsxx_hal_dma.c stm32h7rsxx_hal_dma2d.c stm32h7rsxx_hal_dma_ex.c stm32h7rsxx_hal_dts.c stm32h7rsxx_hal_eth.c stm32h7rsxx_hal_eth_ex.c stm32h7rsxx_hal_exti.c stm32h7rsxx_hal_fdcan.c stm32h7rsxx_hal_flash.c stm32h7rsxx_hal_flash_ex.c stm32h7rsxx_hal_gfxmmu.c stm32h7rsxx_hal_gfxtim.c stm32h7rsxx_hal_gpio.c stm32h7rsxx_hal_gpu2d.c stm32h7rsxx_hal_hash.c stm32h7rsxx_hal_hcd.c stm32h7rsxx_hal_i2c.c stm32h7rsxx_hal_i2c_ex.c stm32h7rsxx_hal_i2s.c stm32h7rsxx_hal_i2s_ex.c stm32h7rsxx_hal_i3c.c stm32h7rsxx_hal_icache.c stm32h7rsxx_hal_irda.c stm32h7rsxx_hal_iwdg.c stm32h7rsxx_hal_jpeg.c stm32h7rsxx_hal_lptim.c stm32h7rsxx_hal_ltdc.c stm32h7rsxx_hal_ltdc_ex.c stm32h7rsxx_hal_mce.c stm32h7rsxx_hal_mdf.c stm32h7rsxx_hal_mdios.c stm32h7rsxx_hal_mmc.c stm32h7rsxx_hal_mmc_ex.c stm32h7rsxx_hal_nand.c stm32h7rsxx_hal_nor.c stm32h7rsxx_hal_pcd.c stm32h7rsxx_hal_pcd_ex.c stm32h7rsxx_hal_pka.c stm32h7rsxx_hal_pssi.c stm32h7rsxx_hal_pwr.c stm32h7rsxx_hal_pwr_ex.c stm32h7rsxx_hal_ramecc.c stm32h7rsxx_hal_rcc.c stm32h7rsxx_hal_rcc_ex.c stm32h7rsxx_hal_rng.c stm32h7rsxx_hal_rng_ex.c stm32h7rsxx_hal_rtc.c stm32h7rsxx_hal_rtc_ex.c stm32h7rsxx_hal_sai.c stm32h7rsxx_hal_sai_ex.c stm32h7rsxx_hal_sd.c stm32h7rsxx_hal_sdram.c stm32h7rsxx_hal_sd_ex.c stm32h7rsxx_hal_smartcard.c stm32h7rsxx_hal_smartcard_ex.c stm32h7rsxx_hal_smbus.c stm32h7rsxx_hal_smbus_ex.c stm32h7rsxx_hal_spdifrx.c stm32h7rsxx_hal_spi.c stm32h7rsxx_hal_spi_ex.c stm32h7rsxx_hal_sram.c stm32h7rsxx_hal_tim.c stm32h7rsxx_hal_tim_ex.c stm32h7rsxx_hal_uart.c stm32h7rsxx_hal_uart_ex.c stm32h7rsxx_hal_usart.c stm32h7rsxx_hal_usart_ex.c stm32h7rsxx_hal_wwdg.c stm32h7rsxx_hal_xspi.c stm32h7rsxx_ll_adc.c stm32h7rsxx_ll_cordic.c stm32h7rsxx_ll_crc.c stm32h7rsxx_ll_crs.c stm32h7rsxx_ll_dlyb.c stm32h7rsxx_ll_dma.c stm32h7rsxx_ll_dma2d.c stm32h7rsxx_ll_exti.c stm32h7rsxx_ll_fmc.c stm32h7rsxx_ll_gpio.c stm32h7rsxx_ll_i2c.c stm32h7rsxx_ll_i3c.c stm32h7rsxx_ll_lptim.c stm32h7rsxx_ll_lpuart.c stm32h7rsxx_ll_pka.c stm32h7rsxx_ll_pwr.c stm32h7rsxx_ll_rcc.c stm32h7rsxx_ll_rng.c stm32h7rsxx_ll_rtc.c stm32h7rsxx_ll_sdmmc.c stm32h7rsxx_ll_spi.c stm32h7rsxx_ll_tim.c stm32h7rsxx_ll_ucpd.c stm32h7rsxx_ll_usart.c stm32h7rsxx_ll_usb.c stm32h7rsxx_util_i3c.c
  group STM32H7xx HAL Drivers Headers
    ../../../../../third_party/st/drivers/stm32h7rsxx_hal_driver/inc/: stm32h7rsxx_hal.h stm32h7rsxx_hal_adc.h stm32h7rsxx_hal_adc_ex.h stm32h7rsxx_hal_cec.h stm32h7rsxx_hal_cordic.h stm32h7rsxx_hal_cortex.h stm32h7rsxx_hal_crc.h stm32h7rsxx_hal_crc_ex.h stm32h7rsxx_hal_cryp.h stm32h7rsxx_hal_cryp_ex.h stm32h7rsxx_hal_dcmipp.h stm32h7rsxx_hal_def.h stm32h7rsxx_hal_dma.h stm32h7rsxx_hal_dma2d.h stm32h7rsxx_hal_dma_ex.h stm32h7rsxx_hal_dts.h stm32h7rsxx_hal_eth.h stm32h7rsxx_hal_eth_ex.h stm32h7rsxx_hal_exti.h stm32h7rsxx_hal_fdcan.h stm32h7rsxx_hal_flash.h stm32h7rsxx_hal_flash_ex.h stm32h7rsxx_hal_gfxmmu.h stm32h7rsxx_hal_gfxtim.h stm32h7rsxx_hal_gpio.h stm32h7rsxx_hal_gpio_ex.h stm32h7rsxx_hal_gpu2d.h stm32h7rsxx_hal_hash.h stm32h7rsxx_hal_hcd.h stm32h7rsxx_hal_i2c.h stm32h7rsxx_hal_i2c_ex.h stm32h7rsxx_hal_i2s.h stm32h7rsxx_hal_i2s_ex.h stm32h7rsxx_hal_i3c.h stm32h7rsxx_hal_icache.h stm32h7rsxx_hal_irda.h stm32h7rsxx_hal_irda_ex.h stm32h7rsxx_hal_iwdg.h stm32h7rsxx_hal_jpeg.h stm32h7rsxx_hal_lptim.h stm32h7rsxx_hal_ltdc.h stm32h7rsxx_hal_ltdc_ex.h stm32h7rsxx_hal_mce.h stm32h7rsxx_hal_mdf.h stm32h7rsxx_hal_mdios.h stm32h7rsxx_hal_mmc.h stm32h7rsxx_hal_mmc_ex.h stm32h7rsxx_hal_nand.h stm32h7rsxx_hal_nor.h stm32h7rsxx_hal_pcd.h stm32h7rsxx_hal_pcd_ex.h stm32h7rsxx_hal_pka.h stm32h7rsxx_hal_pssi.h stm32h7rsxx_hal_pwr.h stm32h7rsxx_hal_pwr_ex.h stm32h7rsxx_hal_ramecc.h stm32h7rsxx_hal_rcc.h stm32h7rsxx_hal_rcc_ex.h stm32h7rsxx_hal_rng.h stm32h7rsxx_hal_rng_ex.h stm32h7rsxx_hal_rtc.h stm32h7rsxx_hal_rtc_ex.h stm32h7rsxx_hal_sai.h stm32h7rsxx_hal_sai_ex.h stm32h7rsxx_hal_sd.h stm32h7rsxx_hal_sdram.h stm32h7rsxx_hal_sd_ex.h stm32h7rsxx_hal_smartcard.h stm32h7rsxx_hal_smartcard_ex.h stm32h7rsxx_hal_smbus.h stm32h7rsxx_hal_smbus_ex.h stm32h7rsxx_hal_spdifrx.h stm32h7rsxx_hal_spi.h stm32h7rsxx_hal_spi_ex.h stm32h7rsxx_hal_sram.h stm32h7rsxx_hal_tim.h stm32h7rsxx_hal_tim_ex.h stm32h7rsxx_hal_uart.h stm32h7rsxx_hal_uart_ex.h stm32h7rsxx_hal_usart.h stm32h7rsxx_hal_usart_ex.h stm32h7rsxx_hal_wwdg.h stm32h7rsxx_hal_xspi.h stm32h7rsxx_ll_adc.h stm32h7rsxx_ll_bus.h stm32h7rsxx_ll_cordic.h stm32h7rsxx_ll_cortex.h stm32h7rsxx_ll_crc.h stm32h7rsxx_ll_crs.h stm32h7rsxx_ll_dlyb.h stm32h7rsxx_ll_dma.h stm32h7rsxx_ll_dma2d.h stm32h7rsxx_ll_exti.h stm32h7rsxx_ll_fmc.h stm32h7rsxx_ll_gpio.h stm32h7rsxx_ll_i2c.h stm32h7rsxx_ll_i3c.h stm32h7rsxx_ll_icache.h stm32h7rsxx_ll_iwdg.h stm32h7rsxx_ll_lptim.h stm32h7rsxx_ll_lpuart.h stm32h7rsxx_ll_pka.h stm32h7rsxx_ll_pwr.h stm32h7rsxx_ll_rcc.h stm32h7rsxx_ll_rng.h stm32h7rsxx_ll_rtc.h stm32h7rsxx_ll_sdmmc.h stm32h7rsxx_ll_spi.h stm32h7rsxx_ll_system.h stm32h7rsxx_ll_tim.h stm32h7rsxx_ll_ucpd.h stm32h7rsxx_ll_usart.h stm32h7rsxx_ll_usb.h stm32h7rsxx_ll_utils.h stm32h7rsxx_ll_wwdg.h stm32h7rsxx_util_i3c.h
target ftp_server_demo_sram (ARM-ADS)
  device: STM32H7S7L8Hx STMicroelectronics
  pack: Keil.STM32H7RSxx_DFP.1.0.0
  cpu: as above
  output: ftp_server_demo_sram
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32H7S7xx USE_HAL_DRIVER USE_STM32H7S78_DK
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\stm32h7s7_sram.sct
